+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958410p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916300p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916310p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916800p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916810p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833100p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833110p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833600p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833610p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666700p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666710p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667200p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667210p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333900p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333910p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334400p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334410p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668300p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668310p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668800p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668810p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337100p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337110p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337600p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337610p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674700p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674710p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675200p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675210p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349900p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349910p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350400p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350410p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700300p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700310p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700800p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700810p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401100p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401110p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401600p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401610p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802700p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802710p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803200p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803210p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605900p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605910p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606400p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606410p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212300p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212310p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212800p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212810p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425100p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425110p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425600p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425610p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850700p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850710p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851200p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851210p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701900p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701910p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702400p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702410p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404300p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404310p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404800p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404810p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809100p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809110p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809600p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809610p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618700p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618710p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619200p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619210p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237900p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237910p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238400p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238410p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476300p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476310p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476800p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476810p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953100p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953110p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953600p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953610p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906700p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906710p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907200p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907210p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813900p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813910p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814400p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814410p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628300p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628310p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628800p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628810p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257100p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257110p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257600p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257610p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514700p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514710p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515200p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515210p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029900p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029910p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030400p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030410p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060300p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060310p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060800p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060810p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121100p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121110p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121600p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121610p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242700p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242710p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243200p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243210p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485900p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485910p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486400p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486410p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972300p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972310p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972800p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972810p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945100p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945110p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945600p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945610p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890700p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890710p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891200p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891210p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781900p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781910p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782400p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782410p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564300p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564310p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564800p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564810p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129100p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129110p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129600p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129610p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258700p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258710p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259200p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259210p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517900p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517910p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518400p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518410p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036300p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036310p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036800p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036810p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073100p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073110p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073600p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073610p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146700p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146710p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147200p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147210p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293900p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293910p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294400p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294410p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588300p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588310p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588800p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588810p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177100p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177110p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177600p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177610p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354700p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354710p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355200p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355210p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709900p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709910p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710400p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710410p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420300p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420310p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420800p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420810p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841100p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841110p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841600p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841610p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682700p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682710p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683200p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683210p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365900p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365910p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366400p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366410p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732300p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732310p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732800p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732810p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465100p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465110p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465600p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465610p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930700p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930710p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931200p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931210p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861900p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861910p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862400p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862410p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724300p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724310p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724800p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724810p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449100p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449110p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449600p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449610p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898700p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898710p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899200p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899210p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797900p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797910p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798400p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798410p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596300p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596310p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596800p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596810p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193100p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193110p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193600p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193610p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386700p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386710p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387200p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387210p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773900p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773910p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774400p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774410p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548300p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548310p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548800p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548810p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097100p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097110p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097600p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097610p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194700p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194710p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195200p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195210p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389900p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389910p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390400p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390410p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780300p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780310p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780800p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780810p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561100p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561110p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561600p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561610p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122700p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122710p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123200p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123210p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245900p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245910p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246400p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246410p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492300p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492310p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492800p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492810p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985100p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985110p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985600p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985610p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970700p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970710p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971200p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971210p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941900p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941910p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942400p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942410p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884300p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884310p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884800p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884810p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769100p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769110p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769600p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769610p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538700p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538710p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539200p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539210p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077900p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077910p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078400p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078410p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156300p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156310p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156800p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156810p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313100p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313110p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313600p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313610p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626700p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626710p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627200p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627210p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253900p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253910p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254400p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254410p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508300p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508310p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508800p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508810p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017100p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017110p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017600p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017610p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034700p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034710p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035200p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035210p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069900p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069910p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070400p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070410p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140300p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140310p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140800p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140810p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281100p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281110p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281600p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281610p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562700p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562710p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563200p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563210p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125900p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125910p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126400p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126410p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252300p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252310p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252800p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252810p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505100p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505110p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505600p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505610p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010700p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010710p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011200p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011210p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021900p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021910p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022400p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022410p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044300p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044310p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044800p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044810p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089100p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089110p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089600p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089610p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178700p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178710p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179200p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179210p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357900p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357910p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358400p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358410p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716300p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716310p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716800p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716810p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433100p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433110p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433600p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433610p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866700p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866710p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867200p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867210p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733900p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733910p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734400p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734410p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468300p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468310p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468800p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468810p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937100p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937110p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937600p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937610p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874700p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874710p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875200p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875210p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749900p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749910p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750400p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750410p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500300p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500310p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500800p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500810p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001100p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001110p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001600p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001610p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002700p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002710p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003200p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003210p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005900p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005910p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006400p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006410p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012300p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012310p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012800p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012810p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025100p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025110p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025600p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025610p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050700p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050710p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051200p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051210p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101900p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101910p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102400p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102410p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204300p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204310p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204800p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204810p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409100p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409110p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409600p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409610p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818700p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818710p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819200p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819210p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637900p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637910p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638400p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638410p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276300p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276310p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276800p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276810p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553100p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553110p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553600p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553610p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106700p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106710p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107200p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107210p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213900p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213910p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214400p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214410p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428300p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428310p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428800p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428810p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857100p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857110p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857600p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857610p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714700p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714710p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715200p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715210p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429900p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429910p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430400p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430410p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860300p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860310p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860800p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860810p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721100p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721110p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721600p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721610p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442700p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442710p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443200p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443210p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885900p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885910p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886400p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886410p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772300p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772310p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772800p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772810p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545100p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545110p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545600p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545610p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090700p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090710p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091200p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091210p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181900p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181910p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182400p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182410p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364300p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364310p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364800p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364810p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729100p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729110p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729600p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729610p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458700p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458710p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459200p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459210p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917900p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917910p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918400p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918410p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836300p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836310p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836800p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836810p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673100p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673110p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673600p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673610p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346700p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346710p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347200p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347210p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693900p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693910p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694400p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694410p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388300p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388310p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388800p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388810p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777100p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777110p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777600p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777610p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554700p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554710p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555200p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555210p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109900p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109910p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110400p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110410p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220300p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220310p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220800p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220810p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441100p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441110p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441600p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441610p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882700p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882710p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883200p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883210p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765900p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765910p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766400p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766410p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532300p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532310p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532800p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532810p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065100p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065110p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065600p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065610p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130700p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130710p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131200p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131210p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261900p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261910p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262400p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262410p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524300p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524310p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524800p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524810p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049100p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049110p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049600p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049610p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098700p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098710p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099200p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099210p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197900p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197910p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198400p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198410p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396300p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396310p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396800p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396810p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793100p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793110p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793600p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793610p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586700p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586710p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587200p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587210p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173900p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173910p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174400p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174410p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348300p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348310p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348800p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348810p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697100p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697110p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697600p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697610p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394700p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394710p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395200p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395210p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789900p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789910p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790400p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790410p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580300p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580310p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580800p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580810p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161100p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161110p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161600p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161610p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322700p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322710p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323200p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323210p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645900p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645910p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646400p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646410p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292300p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292310p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292800p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292810p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585100p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585110p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585600p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585610p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170700p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170710p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171200p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171210p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341900p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341910p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342400p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342410p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684300p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684310p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684800p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684810p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369100p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369110p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369600p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369610p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738700p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738710p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739200p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739210p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477900p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477910p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478400p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478410p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956300p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956310p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956800p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956810p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913100p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913110p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913600p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913610p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826700p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826710p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827200p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827210p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653900p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653910p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654400p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654410p 0.9
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308300p 0.9
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308310p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308800p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308810p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617100p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617110p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617600p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617610p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234700p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234710p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235200p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235210p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469900p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469910p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470400p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470410p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940300p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940310p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940800p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940810p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881100p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881110p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881600p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881610p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762700p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762710p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763200p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763210p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525900p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525910p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526400p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526410p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052300p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052310p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052800p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052810p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105100p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105110p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105600p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105610p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210700p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210710p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211200p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211210p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421900p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421910p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422400p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422410p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844300p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844310p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844800p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844810p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689100p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689110p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689600p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689610p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378700p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378710p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379200p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379210p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757900p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757910p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758400p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758410p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516300p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516310p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516800p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516810p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033100p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033110p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033600p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033610p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066700p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066710p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067200p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067210p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133900p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133910p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134400p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134410p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268300p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268310p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268800p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268810p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537100p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537110p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537600p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537610p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074700p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074710p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075200p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075210p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149900p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149910p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150400p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150410p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300300p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300310p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300800p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300810p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601100p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601110p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601600p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601610p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202700p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202710p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203200p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203210p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405900p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405910p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406400p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406410p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812300p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812310p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812800p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812810p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625100p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625110p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625600p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625610p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250700p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250710p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251200p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251210p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501900p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501910p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502400p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502410p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004300p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004310p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004800p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004810p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009100p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009110p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009600p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009610p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018700p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018710p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019200p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019210p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037900p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037910p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038400p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038410p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076300p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076310p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076800p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076810p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153100p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153110p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153600p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153610p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306700p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306710p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307200p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307210p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613900p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613910p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614400p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614410p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228300p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228310p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228800p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228810p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457100p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457110p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457600p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457610p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914700p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914710p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915200p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915210p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829900p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829910p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830400p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830410p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660300p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660310p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660800p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660810p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321100p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321110p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321600p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321610p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642700p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642710p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643200p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643210p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285900p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285910p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286400p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286410p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572300p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572310p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572800p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572810p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145100p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145110p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145600p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145610p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290700p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290710p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291200p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291210p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581900p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581910p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582400p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582410p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164300p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164310p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164800p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164810p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329100p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329110p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329600p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329610p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658700p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658710p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659200p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659210p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317900p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317910p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318400p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318410p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636300p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636310p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636800p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636810p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273100p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273110p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273600p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273610p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546700p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546710p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547200p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547210p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093900p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093910p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094400p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094410p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188300p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188310p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188800p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188810p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377100p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377110p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377600p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377610p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754700p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754710p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755200p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755210p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509900p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509910p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510400p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510410p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020300p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020310p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020800p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020810p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041100p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041110p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041600p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041610p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082700p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082710p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083200p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083210p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165900p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165910p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166400p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166410p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332300p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332310p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332800p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332810p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665100p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665110p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665600p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665610p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330700p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330710p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331200p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331210p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661900p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661910p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662400p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662410p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324300p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324310p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324800p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324810p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649100p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649110p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649600p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649610p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298700p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298710p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299200p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299210p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597900p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597910p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598400p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598410p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196300p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196310p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196800p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196810p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393100p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393110p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393600p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393610p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786700p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786710p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787200p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787210p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573900p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573910p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574400p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574410p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148300p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148310p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148800p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148810p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297100p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297110p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297600p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297610p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594700p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594710p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595200p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595210p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189900p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189910p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190400p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190410p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380300p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380310p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380800p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380810p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761100p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761110p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761600p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761610p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522700p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522710p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523200p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523210p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045900p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045910p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046400p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046410p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092300p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092310p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092800p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092810p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185100p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185110p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185600p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185610p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370700p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370710p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371200p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371210p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741900p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741910p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742400p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742410p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484300p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484310p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484800p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484810p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969100p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969110p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969600p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969610p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938700p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938710p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939200p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939210p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877900p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877910p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878400p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878410p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756300p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756310p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756800p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756810p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513100p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513110p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513600p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513610p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026700p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026710p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027200p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027210p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053900p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053910p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054400p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054410p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108300p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108310p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108800p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108810p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217100p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217110p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217600p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217610p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434700p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434710p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435200p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435210p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869900p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869910p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870400p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870410p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740300p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740310p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740800p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740810p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481100p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481110p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481600p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481610p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962700p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962710p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963200p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963210p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925900p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925910p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926400p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926410p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852300p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852310p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852800p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852810p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705100p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705110p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705600p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705610p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410700p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410710p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411200p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411210p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821900p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821910p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822400p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822410p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644300p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644310p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644800p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644810p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289100p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289110p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289600p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289610p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578700p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578710p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579200p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579210p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157900p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157910p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158400p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158410p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316300p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316310p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316800p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316810p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633100p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633110p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633600p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633610p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266700p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266710p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267200p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267210p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533900p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533910p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534400p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534410p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068300p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068310p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068800p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068810p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137100p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137110p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137600p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137610p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274700p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274710p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275200p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275210p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549900p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549910p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550400p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550410p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100300p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100310p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100800p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100810p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201100p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201110p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201600p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201610p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402700p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402710p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403200p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403210p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805900p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805910p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806400p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806410p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612300p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612310p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612800p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612810p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225100p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225110p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225600p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225610p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450700p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450710p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451200p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451210p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901900p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901910p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902400p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902410p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804300p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804310p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804800p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804810p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609100p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609110p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609600p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609610p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218700p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218710p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219200p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219210p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437900p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437910p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438400p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438410p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876300p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876310p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876800p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876810p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753100p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753110p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753600p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753610p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506700p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506710p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507200p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507210p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013900p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013910p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014400p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014410p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028300p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028310p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028800p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028810p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057100p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057110p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057600p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057610p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114700p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114710p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115200p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115210p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229900p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229910p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230400p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230410p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460300p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460310p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460800p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460810p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921100p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921110p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921600p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921610p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842700p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842710p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843200p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843210p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685900p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685910p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686400p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686410p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372300p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372310p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372800p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372810p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745100p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745110p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745600p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745610p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490700p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490710p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491200p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491210p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981900p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981910p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982400p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982410p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964300p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964310p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964800p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964810p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929100p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929110p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929600p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929610p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858700p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858710p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859200p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859210p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717900p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717910p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718400p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718410p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436300p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436310p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436800p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436810p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873100p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873110p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873600p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873610p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746700p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746710p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747200p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747210p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493900p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493910p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494400p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494410p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988300p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988310p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988800p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988810p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977100p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977110p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977600p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977610p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954700p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954710p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955200p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955210p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909900p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909910p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910400p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910410p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820300p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820310p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820800p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820810p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641100p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641110p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641600p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641610p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282700p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282710p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283200p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283210p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565900p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565910p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566400p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566410p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132300p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132310p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132800p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132810p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265100p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265110p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265600p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265610p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530700p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530710p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531200p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531210p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061900p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061910p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062400p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062410p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124300p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124310p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124800p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124810p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249100p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249110p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249600p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249610p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498700p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498710p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499200p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499210p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997900p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997910p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998400p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998410p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996300p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996310p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996800p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996810p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993100p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993110p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993600p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993610p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986700p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986710p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987200p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987210p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973900p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973910p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974400p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974410p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948300p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948310p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948800p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948810p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897100p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897110p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897600p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897610p 0.9
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794700p 0.9
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794710p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795200p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795210p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589900p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589910p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590400p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590410p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180300p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180310p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180800p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180810p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361100p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361110p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361600p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361610p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722700p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722710p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723200p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723210p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445900p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445910p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446400p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446410p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892300p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892310p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892800p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892810p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785100p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785110p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785600p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785610p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570700p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570710p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571200p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571210p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141900p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141910p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142400p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142410p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284300p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284310p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284800p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284810p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569100p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569110p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569600p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569610p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138700p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138710p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139200p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139210p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277900p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277910p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278400p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278410p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556300p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556310p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556800p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556810p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113100p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113110p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113600p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113610p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226700p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226710p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227200p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227210p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453900p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453910p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454400p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454410p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908300p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908310p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908800p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908810p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817100p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817110p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817600p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817610p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634700p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634710p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635200p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635210p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269900p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269910p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270400p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270410p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540300p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540310p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540800p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540810p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081100p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081110p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081600p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081610p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162700p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162710p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163200p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163210p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325900p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325910p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326400p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326410p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652300p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652310p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652800p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652810p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305100p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305110p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305600p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305610p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610700p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610710p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611200p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611210p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221900p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221910p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222400p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222410p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444300p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444310p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444800p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444810p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889100p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889110p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889600p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889610p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778700p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778710p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779200p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779210p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557900p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557910p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558400p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558410p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116300p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116310p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116800p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116810p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233100p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233110p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233600p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233610p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466700p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466710p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467200p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467210p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933900p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933910p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934400p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934410p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868300p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868310p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868800p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868810p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737100p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737110p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737600p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737610p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474700p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474710p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475200p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475210p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949900p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949910p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950400p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950410p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900300p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900310p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900800p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900810p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801100p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801110p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801600p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801610p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602700p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602710p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603200p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603210p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205900p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205910p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206400p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206410p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412300p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412310p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412800p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412810p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825100p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825110p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825600p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825610p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650700p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650710p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651200p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651210p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301900p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301910p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302400p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302410p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604300p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604310p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604800p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604810p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209100p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209110p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209600p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209610p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418700p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418710p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419200p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419210p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837900p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837910p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838400p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838410p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676300p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676310p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676800p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676810p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353100p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353110p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353600p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353610p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706700p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706710p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707200p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707210p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413900p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413910p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414400p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414410p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828300p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828310p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828800p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828810p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657100p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657110p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657600p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657610p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314700p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314710p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315200p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315210p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629900p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629910p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630400p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630410p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260300p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260310p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260800p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260810p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521100p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521110p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521600p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521610p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042700p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042710p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043200p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043210p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085900p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085910p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086400p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086410p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172300p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172310p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172800p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172810p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345100p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345110p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345600p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345610p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690700p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690710p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691200p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691210p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381900p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381910p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382400p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382410p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764300p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764310p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764800p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764810p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529100p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529110p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529600p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529610p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058700p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058710p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059200p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059210p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117900p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117910p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118400p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118410p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236300p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236310p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236800p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236810p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473100p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473110p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473600p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473610p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946700p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946710p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947200p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947210p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893900p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893910p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894400p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894410p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788300p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788310p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788800p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788810p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577100p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577110p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577600p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577610p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154700p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154710p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155200p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155210p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309900p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309910p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310400p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310410p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620300p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620310p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620800p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620810p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241100p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241110p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241600p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241610p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482700p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482710p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483200p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483210p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965900p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965910p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966400p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966410p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932300p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932310p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932800p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932810p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865100p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865110p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865600p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865610p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730700p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730710p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731200p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731210p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461900p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461910p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462400p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462410p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924300p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924310p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924800p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924810p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849100p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849110p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849600p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849610p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698700p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698710p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699200p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699210p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397900p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397910p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398400p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398410p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796300p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796310p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796800p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796810p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593100p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593110p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593600p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593610p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186700p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186710p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187200p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187210p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373900p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373910p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374400p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374410p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748300p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748310p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748800p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748810p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497100p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497110p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497600p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497610p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994700p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994710p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995200p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995210p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989900p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989910p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990400p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990410p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980300p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980310p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980800p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980810p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961100p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961110p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961600p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961610p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922700p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922710p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923200p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923210p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845900p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845910p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846400p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846410p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692300p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692310p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692800p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692810p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385100p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385110p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385600p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385610p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770700p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770710p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771200p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771210p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541900p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541910p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542400p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542410p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084300p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084310p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084800p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084810p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169100p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169110p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169600p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169610p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338700p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338710p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339200p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339210p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677900p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677910p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678400p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678410p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356300p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356310p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356800p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356810p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713100p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713110p -0.3
