+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308810p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617100p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617110p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617600p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617610p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234700p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234710p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235200p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235210p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469900p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469910p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470400p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470410p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940300p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940310p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940800p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940810p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881100p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881110p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881600p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881610p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762700p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762710p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763200p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763210p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525900p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525910p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526400p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526410p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052300p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052310p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052800p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052810p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105100p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105110p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105600p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105610p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210700p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210710p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211200p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211210p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421900p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421910p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422400p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422410p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844300p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844310p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844800p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844810p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689100p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689110p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689600p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689610p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378700p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378710p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379200p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379210p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757900p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757910p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758400p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758410p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516300p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516310p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516800p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516810p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033100p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033110p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033600p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033610p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066700p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066710p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067200p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067210p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133900p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133910p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134400p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134410p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268300p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268310p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268800p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268810p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537100p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537110p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537600p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537610p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074700p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074710p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075200p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075210p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149900p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149910p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150400p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150410p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300300p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300310p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300800p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300810p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601100p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601110p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601600p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601610p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202700p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202710p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203200p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203210p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405900p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405910p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406400p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406410p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812300p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812310p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812800p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812810p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625100p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625110p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625600p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625610p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250700p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250710p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251200p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251210p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501900p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501910p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502400p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502410p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004300p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004310p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004800p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004810p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009100p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009110p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009600p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009610p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018700p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018710p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019200p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019210p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037900p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037910p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038400p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038410p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076300p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076310p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076800p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076810p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153100p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153110p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153600p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153610p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306700p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306710p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307200p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307210p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613900p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613910p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614400p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614410p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228300p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228310p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228800p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228810p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457100p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457110p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457600p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457610p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914700p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914710p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915200p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915210p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829900p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829910p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830400p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830410p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660300p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660310p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660800p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660810p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321100p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321110p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321600p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321610p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642700p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642710p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643200p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643210p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285900p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285910p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286400p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286410p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572300p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572310p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572800p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572810p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145100p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145110p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145600p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145610p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290700p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290710p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291200p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291210p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581900p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581910p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582400p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582410p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164300p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164310p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164800p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164810p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329100p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329110p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329600p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329610p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658700p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658710p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659200p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659210p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317900p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317910p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318400p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318410p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636300p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636310p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636800p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636810p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273100p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273110p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273600p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273610p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546700p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546710p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547200p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547210p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093900p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093910p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094400p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094410p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188300p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188310p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188800p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188810p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377100p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377110p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377600p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377610p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754700p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754710p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755200p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755210p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509900p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509910p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510400p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510410p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020300p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020310p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020800p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020810p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041100p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041110p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041600p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041610p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082700p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082710p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083200p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083210p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165900p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165910p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166400p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166410p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332300p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332310p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332800p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332810p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665100p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665110p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665600p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665610p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330700p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330710p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331200p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331210p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661900p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661910p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662400p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662410p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324300p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324310p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324800p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324810p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649100p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649110p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649600p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649610p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298700p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298710p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299200p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299210p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597900p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597910p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598400p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598410p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196300p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196310p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196800p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196810p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393100p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393110p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393600p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393610p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786700p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786710p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787200p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787210p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573900p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573910p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574400p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574410p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148300p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148310p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148800p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148810p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297100p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297110p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297600p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297610p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594700p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594710p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595200p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595210p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189900p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189910p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190400p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190410p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380300p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380310p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380800p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380810p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761100p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761110p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761600p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761610p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522700p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522710p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523200p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523210p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045900p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045910p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046400p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046410p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092300p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092310p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092800p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092810p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185100p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185110p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185600p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185610p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370700p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370710p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371200p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371210p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741900p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741910p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742400p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742410p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484300p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484310p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484800p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484810p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969100p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969110p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969600p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969610p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938700p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938710p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939200p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939210p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877900p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877910p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878400p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878410p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756300p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756310p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756800p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756810p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513100p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513110p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513600p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513610p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026700p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026710p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027200p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027210p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053900p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053910p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054400p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054410p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108300p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108310p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108800p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108810p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217100p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217110p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217600p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217610p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434700p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434710p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435200p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435210p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869900p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869910p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870400p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870410p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740300p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740310p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740800p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740810p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481100p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481110p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481600p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481610p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962700p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962710p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963200p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963210p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925900p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925910p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926400p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926410p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852300p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852310p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852800p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852810p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705100p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705110p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705600p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705610p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410700p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410710p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411200p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411210p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821900p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821910p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822400p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822410p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644300p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644310p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644800p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644810p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289100p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289110p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289600p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289610p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578700p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578710p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579200p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579210p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157900p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157910p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158400p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158410p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316300p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316310p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316800p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316810p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633100p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633110p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633600p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633610p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266700p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266710p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267200p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267210p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533900p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533910p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534400p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534410p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068300p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068310p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068800p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068810p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137100p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137110p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137600p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137610p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274700p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274710p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275200p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275210p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549900p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549910p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550400p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550410p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100300p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100310p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100800p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100810p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201100p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201110p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201600p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201610p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402700p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402710p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403200p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403210p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805900p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805910p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806400p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806410p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612300p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612310p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612800p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612810p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225100p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225110p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225600p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225610p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450700p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450710p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451200p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451210p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901900p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901910p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902400p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902410p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804300p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804310p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804800p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804810p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609100p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609110p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609600p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609610p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218700p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218710p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219200p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219210p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437900p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437910p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438400p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438410p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876300p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876310p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876800p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876810p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753100p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753110p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753600p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753610p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506700p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506710p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507200p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507210p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013900p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013910p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014400p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014410p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028300p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028310p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028800p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028810p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057100p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057110p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057600p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057610p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114700p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114710p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115200p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115210p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229900p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229910p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230400p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230410p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460300p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460310p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460800p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460810p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921100p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921110p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921600p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921610p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842700p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842710p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843200p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843210p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685900p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685910p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686400p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686410p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372300p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372310p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372800p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372810p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745100p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745110p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745600p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745610p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490700p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490710p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491200p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491210p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981900p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981910p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982400p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982410p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964300p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964310p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964800p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964810p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929100p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929110p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929600p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929610p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858700p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858710p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859200p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859210p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717900p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717910p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718400p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718410p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436300p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436310p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436800p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436810p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873100p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873110p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873600p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873610p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746700p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746710p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747200p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747210p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493900p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493910p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494400p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494410p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988300p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988310p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988800p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988810p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977100p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977110p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977600p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977610p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954700p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954710p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955200p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955210p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909900p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909910p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910400p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910410p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820300p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820310p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820800p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820810p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641100p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641110p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641600p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641610p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282700p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282710p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283200p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283210p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565900p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565910p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566400p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566410p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132300p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132310p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132800p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132810p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265100p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265110p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265600p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265610p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530700p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530710p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531200p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531210p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061900p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061910p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062400p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062410p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124300p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124310p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124800p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124810p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249100p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249110p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249600p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249610p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498700p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498710p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499200p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499210p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997900p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997910p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998400p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998410p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996300p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996310p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996800p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996810p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993100p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993110p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993600p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993610p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986700p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986710p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987200p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987210p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973900p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973910p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974400p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974410p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948300p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948310p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948800p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948810p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897100p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897110p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897600p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897610p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794700p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794710p 0.9
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795200p 0.9
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795210p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589900p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589910p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590400p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590410p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180300p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180310p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180800p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180810p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361100p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361110p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361600p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361610p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722700p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722710p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723200p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723210p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445900p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445910p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446400p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446410p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892300p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892310p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892800p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892810p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785100p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785110p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785600p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785610p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570700p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570710p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571200p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571210p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141900p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141910p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142400p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142410p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284300p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284310p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284800p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284810p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569100p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569110p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569600p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569610p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138700p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138710p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139200p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139210p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277900p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277910p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278400p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278410p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556300p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556310p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556800p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556810p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113100p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113110p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113600p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113610p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226700p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226710p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227200p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227210p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453900p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453910p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454400p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454410p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908300p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908310p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908800p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908810p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817100p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817110p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817600p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817610p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634700p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634710p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635200p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635210p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269900p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269910p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270400p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270410p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540300p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540310p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540800p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540810p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081100p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081110p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081600p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081610p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162700p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162710p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163200p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163210p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325900p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325910p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326400p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326410p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652300p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652310p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652800p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652810p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305100p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305110p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305600p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305610p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610700p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610710p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611200p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611210p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221900p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221910p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222400p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222410p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444300p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444310p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444800p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444810p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889100p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889110p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889600p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889610p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778700p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778710p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779200p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779210p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557900p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557910p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558400p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558410p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116300p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116310p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116800p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116810p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233100p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233110p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233600p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233610p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466700p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466710p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467200p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467210p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933900p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933910p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934400p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934410p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868300p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868310p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868800p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868810p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737100p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737110p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737600p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737610p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474700p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474710p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475200p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475210p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949900p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949910p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950400p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950410p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900300p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900310p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900800p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900810p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801100p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801110p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801600p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801610p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602700p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602710p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603200p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603210p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205900p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205910p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206400p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206410p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412300p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412310p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412800p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412810p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825100p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825110p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825600p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825610p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650700p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650710p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651200p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651210p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301900p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301910p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302400p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302410p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604300p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604310p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604800p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604810p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209100p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209110p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209600p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209610p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418700p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418710p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419200p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419210p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837900p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837910p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838400p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838410p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676300p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676310p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676800p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676810p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353100p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353110p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353600p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353610p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706700p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706710p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707200p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707210p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413900p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413910p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414400p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414410p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828300p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828310p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828800p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828810p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657100p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657110p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657600p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657610p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314700p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314710p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315200p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315210p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629900p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629910p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630400p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630410p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260300p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260310p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260800p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260810p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521100p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521110p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521600p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521610p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042700p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042710p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043200p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043210p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085900p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085910p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086400p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086410p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172300p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172310p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172800p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172810p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345100p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345110p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345600p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345610p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690700p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690710p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691200p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691210p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381900p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381910p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382400p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382410p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764300p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764310p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764800p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764810p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529100p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529110p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529600p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529610p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058700p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058710p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059200p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059210p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117900p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117910p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118400p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118410p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236300p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236310p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236800p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236810p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473100p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473110p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473600p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473610p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946700p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946710p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947200p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947210p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893900p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893910p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894400p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894410p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788300p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788310p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788800p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788810p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577100p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577110p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577600p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577610p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154700p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154710p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155200p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155210p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309900p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309910p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310400p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310410p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620300p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620310p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620800p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620810p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241100p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241110p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241600p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241610p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482700p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482710p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483200p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483210p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965900p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965910p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966400p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966410p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932300p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932310p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932800p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932810p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865100p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865110p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865600p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865610p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730700p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730710p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731200p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731210p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461900p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461910p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462400p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462410p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924300p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924310p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924800p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924810p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849100p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849110p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849600p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849610p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698700p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698710p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699200p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699210p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397900p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397910p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398400p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398410p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796300p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796310p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796800p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796810p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593100p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593110p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593600p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593610p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186700p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186710p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187200p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187210p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373900p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373910p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374400p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374410p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748300p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748310p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748800p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748810p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497100p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497110p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497600p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497610p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994700p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994710p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995200p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995210p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989900p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989910p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990400p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990410p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980300p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980310p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980800p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980810p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961100p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961110p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961600p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961610p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922700p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922710p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923200p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923210p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845900p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845910p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846400p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846410p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692300p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692310p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692800p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692810p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385100p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385110p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385600p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385610p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770700p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770710p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771200p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771210p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541900p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541910p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542400p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542410p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084300p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084310p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084800p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084810p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169100p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169110p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169600p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169610p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338700p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338710p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339200p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339210p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677900p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677910p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678400p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678410p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356300p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356310p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356800p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356810p -0.3
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713100p -0.3
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713110p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713600p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713610p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426700p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426710p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427200p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427210p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853900p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853910p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854400p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854410p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708300p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708310p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708800p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708810p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417100p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417110p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417600p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417610p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834700p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834710p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835200p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835210p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669900p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669910p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670400p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670410p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340300p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340310p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340800p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340810p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681100p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681110p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681600p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681610p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362700p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362710p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363200p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363210p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725900p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725910p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726400p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726410p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452300p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452310p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452800p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452810p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905100p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905110p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905600p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905610p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810700p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810710p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811200p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811210p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621900p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621910p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622400p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622410p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244300p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244310p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244800p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244810p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489100p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489110p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489600p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489610p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978700p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978710p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979200p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979210p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957900p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957910p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958400p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958410p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916300p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916310p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916800p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916810p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833100p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833110p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833600p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833610p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666700p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666710p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667200p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667210p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333900p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333910p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334400p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334410p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668300p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668310p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668800p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668810p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337100p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337110p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337600p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337610p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674700p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674710p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675200p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675210p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349900p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349910p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350400p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350410p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700300p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700310p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700800p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700810p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401100p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401110p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401600p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401610p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802700p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802710p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803200p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803210p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605900p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605910p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606400p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606410p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212300p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212310p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212800p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212810p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425100p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425110p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425600p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425610p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850700p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850710p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851200p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851210p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701900p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701910p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702400p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702410p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404300p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404310p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404800p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404810p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809100p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809110p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809600p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809610p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618700p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618710p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619200p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619210p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237900p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237910p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238400p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238410p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476300p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476310p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476800p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476810p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953100p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953110p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953600p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953610p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906700p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906710p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907200p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907210p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813900p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813910p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814400p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814410p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628300p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628310p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628800p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628810p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257100p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257110p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257600p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257610p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514700p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514710p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515200p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515210p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029900p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029910p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030400p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030410p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060300p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060310p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060800p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060810p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121100p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121110p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121600p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121610p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242700p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242710p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243200p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243210p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485900p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485910p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486400p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486410p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972300p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972310p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972800p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972810p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945100p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945110p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945600p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945610p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890700p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890710p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891200p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891210p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781900p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781910p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782400p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782410p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564300p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564310p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564800p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564810p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129100p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129110p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129600p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129610p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258700p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258710p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259200p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259210p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517900p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517910p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518400p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518410p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036300p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036310p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036800p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036810p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073100p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073110p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073600p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073610p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146700p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146710p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147200p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147210p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293900p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293910p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294400p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294410p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588300p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588310p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588800p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588810p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177100p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177110p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177600p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177610p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354700p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354710p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355200p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355210p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709900p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709910p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710400p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710410p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420300p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420310p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420800p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420810p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841100p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841110p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841600p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841610p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682700p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682710p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683200p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683210p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365900p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365910p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366400p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366410p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732300p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732310p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732800p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732810p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465100p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465110p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465600p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465610p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930700p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930710p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931200p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931210p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861900p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861910p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862400p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862410p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724300p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724310p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724800p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724810p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449100p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449110p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449600p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449610p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898700p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898710p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899200p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899210p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797900p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797910p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798400p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798410p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596300p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596310p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596800p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596810p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193100p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193110p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193600p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193610p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386700p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386710p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387200p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387210p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773900p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773910p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774400p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774410p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548300p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548310p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548800p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548810p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097100p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097110p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097600p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097610p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194700p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194710p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195200p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195210p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389900p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389910p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390400p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390410p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780300p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780310p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780800p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780810p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561100p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561110p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561600p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561610p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122700p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122710p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123200p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123210p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245900p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245910p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246400p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246410p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492300p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492310p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492800p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492810p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985100p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985110p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985600p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985610p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970700p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970710p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971200p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971210p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941900p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941910p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942400p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942410p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884300p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884310p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884800p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884810p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769100p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769110p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769600p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769610p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538700p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538710p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539200p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539210p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077900p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077910p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078400p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078410p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156300p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156310p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156800p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156810p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313100p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313110p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313600p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313610p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626700p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626710p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627200p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627210p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253900p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253910p 0.9
