+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795210p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589900p -0.3
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135589910p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590400p 0.9
+ 556422484280574082357394248664960915804067948534624065432236250428536661442797476060986821724186897697454802681851776637091894287810749477893632559374759320290876663405872606149215078370364882625374258911027982400319996312407675135590410p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180300p -0.3
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180310p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180800p 0.9
+ 1112844968561148164714788497329921831608135897069248130864472500857073322885594952121973643448373795394909605363703553274183788575621498955787265118749518640581753326811745212298430156740729765250748517822055964800639992624815350271180810p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361100p -0.3
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361110p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361600p 0.9
+ 2225689937122296329429576994659843663216271794138496261728945001714146645771189904243947286896747590789819210727407106548367577151242997911574530237499037281163506653623490424596860313481459530501497035644111929601279985249630700542361610p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722700p -0.3
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084722710p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723200p 0.9
+ 4451379874244592658859153989319687326432543588276992523457890003428293291542379808487894573793495181579638421454814213096735154302485995823149060474998074562327013307246980849193720626962919061002994071288223859202559970499261401084723210p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445900p -0.3
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169445910p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446400p 0.9
+ 8902759748489185317718307978639374652865087176553985046915780006856586583084759616975789147586990363159276842909628426193470308604971991646298120949996149124654026614493961698387441253925838122005988142576447718405119940998522802169446410p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892300p -0.3
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892310p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892800p 0.9
+ 17805519496978370635436615957278749305730174353107970093831560013713173166169519233951578295173980726318553685819256852386940617209943983292596241899992298249308053228987923396774882507851676244011976285152895436810239881997045604338892810p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785100p -0.3
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785110p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785600p 0.9
+ 35611038993956741270873231914557498611460348706215940187663120027426346332339038467903156590347961452637107371638513704773881234419887966585192483799984596498616106457975846793549765015703352488023952570305790873620479763994091208677785610p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570700p -0.3
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355570710p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571200p 0.9
+ 71222077987913482541746463829114997222920697412431880375326240054852692664678076935806313180695922905274214743277027409547762468839775933170384967599969192997232212915951693587099530031406704976047905140611581747240959527988182417355571210p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141900p -0.3
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711141910p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142400p 0.9
+ 142444155975826965083492927658229994445841394824863760750652480109705385329356153871612626361391845810548429486554054819095524937679551866340769935199938385994464425831903387174199060062813409952095810281223163494481919055976364834711142410p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284300p -0.3
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284310p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284800p 0.9
+ 284888311951653930166985855316459988891682789649727521501304960219410770658712307743225252722783691621096858973108109638191049875359103732681539870399876771988928851663806774348398120125626819904191620562446326988963838111952729669422284810p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569100p -0.3
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569110p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569600p 0.9
+ 569776623903307860333971710632919977783365579299455043002609920438821541317424615486450505445567383242193717946216219276382099750718207465363079740799753543977857703327613548696796240251253639808383241124892653977927676223905459338844569610p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138700p -0.3
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689138710p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139200p 0.9
+ 1139553247806615720667943421265839955566731158598910086005219840877643082634849230972901010891134766484387435892432438552764199501436414930726159481599507087955715406655227097393592480502507279616766482249785307955855352447810918677689139210p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277900p -0.3
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378277910p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278400p 0.9
+ 2279106495613231441335886842531679911133462317197820172010439681755286165269698461945802021782269532968774871784864877105528399002872829861452318963199014175911430813310454194787184961005014559233532964499570615911710704895621837355378278410p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556300p -0.3
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556310p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556800p 0.9
+ 4558212991226462882671773685063359822266924634395640344020879363510572330539396923891604043564539065937549743569729754211056798005745659722904637926398028351822861626620908389574369922010029118467065928999141231823421409791243674710756556810p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113100p -0.3
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113110p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113600p 0.9
+ 9116425982452925765343547370126719644533849268791280688041758727021144661078793847783208087129078131875099487139459508422113596011491319445809275852796056703645723253241816779148739844020058236934131857998282463646842819582487349421513113610p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226700p -0.3
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026226710p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227200p 0.9
+ 18232851964905851530687094740253439289067698537582561376083517454042289322157587695566416174258156263750198974278919016844227192022982638891618551705592113407291446506483633558297479688040116473868263715996564927293685639164974698843026227210p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453900p -0.3
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052453910p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454400p 0.9
+ 36465703929811703061374189480506878578135397075165122752167034908084578644315175391132832348516312527500397948557838033688454384045965277783237103411184226814582893012967267116594959376080232947736527431993129854587371278329949397686052454410p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908300p -0.3
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908310p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908800p 0.9
+ 72931407859623406122748378961013757156270794150330245504334069816169157288630350782265664697032625055000795897115676067376908768091930555566474206822368453629165786025934534233189918752160465895473054863986259709174742556659898795372104908810p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817100p -0.3
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817110p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817600p 0.9
+ 145862815719246812245496757922027514312541588300660491008668139632338314577260701564531329394065250110001591794231352134753817536183861111132948413644736907258331572051869068466379837504320931790946109727972519418349485113319797590744209817610p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634700p -0.3
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419634710p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635200p 0.9
+ 291725631438493624490993515844055028625083176601320982017336279264676629154521403129062658788130500220003183588462704269507635072367722222265896827289473814516663144103738136932759675008641863581892219455945038836698970226639595181488419635210p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269900p -0.3
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839269910p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270400p 0.9
+ 583451262876987248981987031688110057250166353202641964034672558529353258309042806258125317576261000440006367176925408539015270144735444444531793654578947629033326288207476273865519350017283727163784438911890077673397940453279190362976839270410p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540300p -0.3
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540310p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540800p 0.9
+ 1166902525753974497963974063376220114500332706405283928069345117058706516618085612516250635152522000880012734353850817078030540289470888889063587309157895258066652576414952547731038700034567454327568877823780155346795880906558380725953678540810p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081100p -0.3
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081110p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081600p 0.9
+ 2333805051507948995927948126752440229000665412810567856138690234117413033236171225032501270305044001760025468707701634156061080578941777778127174618315790516133305152829905095462077400069134908655137755647560310693591761813116761451907357081610p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162700p -0.3
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714162710p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163200p 0.9
+ 4667610103015897991855896253504880458001330825621135712277380468234826066472342450065002540610088003520050937415403268312122161157883555556254349236631581032266610305659810190924154800138269817310275511295120621387183523626233522903814714163210p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325900p -0.3
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428325910p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326400p 0.9
+ 9335220206031795983711792507009760916002661651242271424554760936469652132944684900130005081220176007040101874830806536624244322315767111112508698473263162064533220611319620381848309600276539634620551022590241242774367047252467045807629428326410p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652300p -0.3
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652310p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652800p 0.9
+ 18670440412063591967423585014019521832005323302484542849109521872939304265889369800260010162440352014080203749661613073248488644631534222225017396946526324129066441222639240763696619200553079269241102045180482485548734094504934091615258856652810p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305100p -0.3
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305110p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305600p 0.9
+ 37340880824127183934847170028039043664010646604969085698219043745878608531778739600520020324880704028160407499323226146496977289263068444450034793893052648258132882445278481527393238401106158538482204090360964971097468189009868183230517713305610p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610700p -0.3
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426610710p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611200p 0.9
+ 74681761648254367869694340056078087328021293209938171396438087491757217063557479201040040649761408056320814998646452292993954578526136888900069587786105296516265764890556963054786476802212317076964408180721929942194936378019736366461035426611210p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221900p -0.3
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853221910p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222400p 0.9
+ 149363523296508735739388680112156174656042586419876342792876174983514434127114958402080081299522816112641629997292904585987909157052273777800139175572210593032531529781113926109572953604424634153928816361443859884389872756039472732922070853222410p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444300p -0.3
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444310p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444800p 0.9
+ 298727046593017471478777360224312349312085172839752685585752349967028868254229916804160162599045632225283259994585809171975818314104547555600278351144421186065063059562227852219145907208849268307857632722887719768779745512078945465844141706444810p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889100p -0.3
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889110p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889600p 0.9
+ 597454093186034942957554720448624698624170345679505371171504699934057736508459833608320325198091264450566519989171618343951636628209095111200556702288842372130126119124455704438291814417698536615715265445775439537559491024157890931688283412889610p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778700p -0.3
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825778710p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779200p 0.9
+ 1194908186372069885915109440897249397248340691359010742343009399868115473016919667216640650396182528901133039978343236687903273256418190222401113404577684744260252238248911408876583628835397073231430530891550879075118982048315781863376566825779210p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557900p -0.3
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651557910p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558400p 0.9
+ 2389816372744139771830218881794498794496681382718021484686018799736230946033839334433281300792365057802266079956686473375806546512836380444802226809155369488520504476497822817753167257670794146462861061783101758150237964096631563726753133651558410p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116300p -0.3
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116310p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116800p 0.9
+ 4779632745488279543660437763588997588993362765436042969372037599472461892067678668866562601584730115604532159913372946751613093025672760889604453618310738977041008952995645635506334515341588292925722123566203516300475928193263127453506267303116810p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233100p -0.3
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233110p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233600p 0.9
+ 9559265490976559087320875527177995177986725530872085938744075198944923784135357337733125203169460231209064319826745893503226186051345521779208907236621477954082017905991291271012669030683176585851444247132407032600951856386526254907012534606233610p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466700p -0.3
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212466710p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467200p 0.9
+ 19118530981953118174641751054355990355973451061744171877488150397889847568270714675466250406338920462418128639653491787006452372102691043558417814473242955908164035811982582542025338061366353171702888494264814065201903712773052509814025069212467210p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933900p -0.3
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424933910p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934400p 0.9
+ 38237061963906236349283502108711980711946902123488343754976300795779695136541429350932500812677840924836257279306983574012904744205382087116835628946485911816328071623965165084050676122732706343405776988529628130403807425546105019628050138424934410p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868300p -0.3
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868310p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868800p 0.9
+ 76474123927812472698567004217423961423893804246976687509952601591559390273082858701865001625355681849672514558613967148025809488410764174233671257892971823632656143247930330168101352245465412686811553977059256260807614851092210039256100276849868810p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737100p -0.3
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737110p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737600p 0.9
+ 152948247855624945397134008434847922847787608493953375019905203183118780546165717403730003250711363699345029117227934296051618976821528348467342515785943647265312286495860660336202704490930825373623107954118512521615229702184420078512200553699737610p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474700p -0.3
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399474710p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475200p 0.9
+ 305896495711249890794268016869695845695575216987906750039810406366237561092331434807460006501422727398690058234455868592103237953643056696934685031571887294530624572991721320672405408981861650747246215908237025043230459404368840157024401107399475210p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949900p -0.3
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798949910p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950400p 0.9
+ 611792991422499781588536033739391691391150433975813500079620812732475122184662869614920013002845454797380116468911737184206475907286113393869370063143774589061249145983442641344810817963723301494492431816474050086460918808737680314048802214798950410p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900300p -0.3
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900310p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900800p 0.9
+ 1223585982844999563177072067478783382782300867951627000159241625464950244369325739229840026005690909594760232937823474368412951814572226787738740126287549178122498291966885282689621635927446602988984863632948100172921837617475360628097604429597900810p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801100p -0.3
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801110p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801600p 0.9
+ 2447171965689999126354144134957566765564601735903254000318483250929900488738651478459680052011381819189520465875646948736825903629144453575477480252575098356244996583933770565379243271854893205977969727265896200345843675234950721256195208859195801610p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602700p -0.3
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391602710p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603200p 0.9
+ 4894343931379998252708288269915133531129203471806508000636966501859800977477302956919360104022763638379040931751293897473651807258288907150954960505150196712489993167867541130758486543709786411955939454531792400691687350469901442512390417718391603210p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205900p -0.3
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783205910p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206400p 0.9
+ 9788687862759996505416576539830267062258406943613016001273933003719601954954605913838720208045527276758081863502587794947303614516577814301909921010300393424979986335735082261516973087419572823911878909063584801383374700939802885024780835436783206410p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412300p -0.3
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412310p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412800p 0.9
+ 19577375725519993010833153079660534124516813887226032002547866007439203909909211827677440416091054553516163727005175589894607229033155628603819842020600786849959972671470164523033946174839145647823757818127169602766749401879605770049561670873566412810p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825100p -0.3
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825110p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825600p 0.9
+ 39154751451039986021666306159321068249033627774452064005095732014878407819818423655354880832182109107032327454010351179789214458066311257207639684041201573699919945342940329046067892349678291295647515636254339205533498803759211540099123341747132825610p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650700p -0.3
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265650710p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651200p 0.9
+ 78309502902079972043332612318642136498067255548904128010191464029756815639636847310709761664364218214064654908020702359578428916132622514415279368082403147399839890685880658092135784699356582591295031272508678411066997607518423080198246683494265651210p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301900p -0.3
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531301910p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302400p 0.9
+ 156619005804159944086665224637284272996134511097808256020382928059513631279273694621419523328728436428129309816041404719156857832265245028830558736164806294799679781371761316184271569398713165182590062545017356822133995215036846160396493366988531302410p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604300p -0.3
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604310p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604800p 0.9
+ 313238011608319888173330449274568545992269022195616512040765856119027262558547389242839046657456872856258619632082809438313715664530490057661117472329612589599359562743522632368543138797426330365180125090034713644267990430073692320792986733977062604810p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209100p -0.3
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209110p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209600p 0.9
+ 626476023216639776346660898549137091984538044391233024081531712238054525117094778485678093314913745712517239264165618876627431329060980115322234944659225179198719125487045264737086277594852660730360250180069427288535980860147384641585973467954125209610p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418700p -0.3
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250418710p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419200p 0.9
+ 1252952046433279552693321797098274183969076088782466048163063424476109050234189556971356186629827491425034478528331237753254862658121960230644469889318450358397438250974090529474172555189705321460720500360138854577071961720294769283171946935908250419210p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837900p -0.3
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500837910p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838400p 0.9
+ 2505904092866559105386643594196548367938152177564932096326126848952218100468379113942712373259654982850068957056662475506509725316243920461288939778636900716794876501948181058948345110379410642921441000720277709154143923440589538566343893871816500838410p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676300p -0.3
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676310p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676800p 0.9
+ 5011808185733118210773287188393096735876304355129864192652253697904436200936758227885424746519309965700137914113324951013019450632487840922577879557273801433589753003896362117896690220758821285842882001440555418308287846881179077132687787743633001676810p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353100p -0.3
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353110p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353600p 0.9
+ 10023616371466236421546574376786193471752608710259728385304507395808872401873516455770849493038619931400275828226649902026038901264975681845155759114547602867179506007792724235793380441517642571685764002881110836616575693762358154265375575487266003353610p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706700p -0.3
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006706710p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707200p 0.9
+ 20047232742932472843093148753572386943505217420519456770609014791617744803747032911541698986077239862800551656453299804052077802529951363690311518229095205734359012015585448471586760883035285143371528005762221673233151387524716308530751150974532006707210p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413900p -0.3
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013413910p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414400p 0.9
+ 40094465485864945686186297507144773887010434841038913541218029583235489607494065823083397972154479725601103312906599608104155605059902727380623036458190411468718024031170896943173521766070570286743056011524443346466302775049432617061502301949064013414410p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828300p -0.3
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828310p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828800p 0.9
+ 80188930971729891372372595014289547774020869682077827082436059166470979214988131646166795944308959451202206625813199216208311210119805454761246072916380822937436048062341793886347043532141140573486112023048886692932605550098865234123004603898128026828810p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657100p -0.3
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657110p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657600p 0.9
+ 160377861943459782744745190028579095548041739364155654164872118332941958429976263292333591888617918902404413251626398432416622420239610909522492145832761645874872096124683587772694087064282281146972224046097773385865211100197730468246009207796256053657610p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314700p -0.3
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107314710p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315200p 0.9
+ 320755723886919565489490380057158191096083478728311308329744236665883916859952526584667183777235837804808826503252796864833244840479221819044984291665523291749744192249367175545388174128564562293944448092195546771730422200395460936492018415592512107315210p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629900p -0.3
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214629910p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630400p 0.9
+ 641511447773839130978980760114316382192166957456622616659488473331767833719905053169334367554471675609617653006505593729666489680958443638089968583331046583499488384498734351090776348257129124587888896184391093543460844400790921872984036831185024214630410p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260300p -0.3
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260310p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260800p 0.9
+ 1283022895547678261957961520228632764384333914913245233318976946663535667439810106338668735108943351219235306013011187459332979361916887276179937166662093166998976768997468702181552696514258249175777792368782187086921688801581843745968073662370048429260810p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521100p -0.3
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521110p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521600p 0.9
+ 2566045791095356523915923040457265528768667829826490466637953893327071334879620212677337470217886702438470612026022374918665958723833774552359874333324186333997953537994937404363105393028516498351555584737564374173843377603163687491936147324740096858521610p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042700p -0.3
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717042710p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043200p 0.9
+ 5132091582190713047831846080914531057537335659652980933275907786654142669759240425354674940435773404876941224052044749837331917447667549104719748666648372667995907075989874808726210786057032996703111169475128748347686755206327374983872294649480193717043210p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085900p -0.3
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434085910p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086400p 0.9
+ 10264183164381426095663692161829062115074671319305961866551815573308285339518480850709349880871546809753882448104089499674663834895335098209439497333296745335991814151979749617452421572114065993406222338950257496695373510412654749967744589298960387434086410p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172300p -0.3
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172310p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172800p 0.9
+ 20528366328762852191327384323658124230149342638611923733103631146616570679036961701418699761743093619507764896208178999349327669790670196418878994666593490671983628303959499234904843144228131986812444677900514993390747020825309499935489178597920774868172810p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345100p -0.3
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345110p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345600p 0.9
+ 41056732657525704382654768647316248460298685277223847466207262293233141358073923402837399523486187239015529792416357998698655339581340392837757989333186981343967256607918998469809686288456263973624889355801029986781494041650618999870978357195841549736345610p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690700p -0.3
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472690710p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691200p 0.9
+ 82113465315051408765309537294632496920597370554447694932414524586466282716147846805674799046972374478031059584832715997397310679162680785675515978666373962687934513215837996939619372576912527947249778711602059973562988083301237999741956714391683099472691210p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381900p -0.3
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945381910p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382400p 0.9
+ 164226930630102817530619074589264993841194741108895389864829049172932565432295693611349598093944748956062119169665431994794621358325361571351031957332747925375869026431675993879238745153825055894499557423204119947125976166602475999483913428783366198945382410p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764300p -0.3
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764310p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764800p 0.9
+ 328453861260205635061238149178529987682389482217790779729658098345865130864591387222699196187889497912124238339330863989589242716650723142702063914665495850751738052863351987758477490307650111788999114846408239894251952333204951998967826857566732397890764810p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529100p -0.3
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529110p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529600p 0.9
+ 656907722520411270122476298357059975364778964435581559459316196691730261729182774445398392375778995824248476678661727979178485433301446285404127829330991701503476105726703975516954980615300223577998229692816479788503904666409903997935653715133464795781529610p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058700p -0.3
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563058710p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059200p 0.9
+ 1313815445040822540244952596714119950729557928871163118918632393383460523458365548890796784751557991648496953357323455958356970866602892570808255658661983403006952211453407951033909961230600447155996459385632959577007809332819807995871307430266929591563059210p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117900p -0.3
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126117910p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118400p 0.9
+ 2627630890081645080489905193428239901459115857742326237837264786766921046916731097781593569503115983296993906714646911916713941733205785141616511317323966806013904422906815902067819922461200894311992918771265919154015618665639615991742614860533859183126118410p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236300p -0.3
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236310p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236800p 0.9
+ 5255261780163290160979810386856479802918231715484652475674529573533842093833462195563187139006231966593987813429293823833427883466411570283233022634647933612027808845813631804135639844922401788623985837542531838308031237331279231983485229721067718366252236810p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473100p -0.3
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473110p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473600p 0.9
+ 10510523560326580321959620773712959605836463430969304951349059147067684187666924391126374278012463933187975626858587647666855766932823140566466045269295867224055617691627263608271279689844803577247971675085063676616062474662558463966970459442135436732504473610p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946700p -0.3
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008946710p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947200p 0.9
+ 21021047120653160643919241547425919211672926861938609902698118294135368375333848782252748556024927866375951253717175295333711533865646281132932090538591734448111235383254527216542559379689607154495943350170127353232124949325116927933940918884270873465008947210p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893900p -0.3
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017893910p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894400p 0.9
+ 42042094241306321287838483094851838423345853723877219805396236588270736750667697564505497112049855732751902507434350590667423067731292562265864181077183468896222470766509054433085118759379214308991886700340254706464249898650233855867881837768541746930017894410p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788300p -0.3
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788310p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788800p 0.9
+ 84084188482612642575676966189703676846691707447754439610792473176541473501335395129010994224099711465503805014868701181334846135462585124531728362154366937792444941533018108866170237518758428617983773400680509412928499797300467711735763675537083493860035788810p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577100p -0.3
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577110p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577600p 0.9
+ 168168376965225285151353932379407353693383414895508879221584946353082947002670790258021988448199422931007610029737402362669692270925170249063456724308733875584889883066036217732340475037516857235967546801361018825856999594600935423471527351074166987720071577610p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154700p -0.3
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143154710p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155200p 0.9
+ 336336753930450570302707864758814707386766829791017758443169892706165894005341580516043976896398845862015220059474804725339384541850340498126913448617467751169779766132072435464680950075033714471935093602722037651713999189201870846943054702148333975440143155210p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309900p -0.3
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286309910p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310400p 0.9
+ 672673507860901140605415729517629414773533659582035516886339785412331788010683161032087953792797691724030440118949609450678769083700680996253826897234935502339559532264144870929361900150067428943870187205444075303427998378403741693886109404296667950880286310410p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620300p -0.3
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620310p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620800p 0.9
+ 1345347015721802281210831459035258829547067319164071033772679570824663576021366322064175907585595383448060880237899218901357538167401361992507653794469871004679119064528289741858723800300134857887740374410888150606855996756807483387772218808593335901760572620810p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241100p -0.3
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241110p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241600p 0.9
+ 2690694031443604562421662918070517659094134638328142067545359141649327152042732644128351815171190766896121760475798437802715076334802723985015307588939742009358238129056579483717447600600269715775480748821776301213711993513614966775544437617186671803521145241610p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482700p -0.3
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290482710p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483200p 0.9
+ 5381388062887209124843325836141035318188269276656284135090718283298654304085465288256703630342381533792243520951596875605430152669605447970030615177879484018716476258113158967434895201200539431550961497643552602427423987027229933551088875234373343607042290483210p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965900p -0.3
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580965910p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966400p 0.9
+ 10762776125774418249686651672282070636376538553312568270181436566597308608170930576513407260684763067584487041903193751210860305339210895940061230355758968037432952516226317934869790402401078863101922995287105204854847974054459867102177750468746687214084580966410p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932300p -0.3
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932310p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932800p 0.9
+ 21525552251548836499373303344564141272753077106625136540362873133194617216341861153026814521369526135168974083806387502421720610678421791880122460711517936074865905032452635869739580804802157726203845990574210409709695948108919734204355500937493374428169161932810p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865100p -0.3
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865110p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865600p 0.9
+ 43051104503097672998746606689128282545506154213250273080725746266389234432683722306053629042739052270337948167612775004843441221356843583760244921423035872149731810064905271739479161609604315452407691981148420819419391896217839468408711001874986748856338323865610p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730700p -0.3
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647730710p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731200p 0.9
+ 86102209006195345997493213378256565091012308426500546161451492532778468865367444612107258085478104540675896335225550009686882442713687167520489842846071744299463620129810543478958323219208630904815383962296841638838783792435678936817422003749973497712676647731210p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461900p -0.3
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295461910p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462400p 0.9
+ 172204418012390691994986426756513130182024616853001092322902985065556937730734889224214516170956209081351792670451100019373764885427374335040979685692143488598927240259621086957916646438417261809630767924593683277677567584871357873634844007499946995425353295462410p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924300p -0.3
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924310p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924800p 0.9
+ 344408836024781383989972853513026260364049233706002184645805970131113875461469778448429032341912418162703585340902200038747529770854748670081959371384286977197854480519242173915833292876834523619261535849187366555355135169742715747269688014999893990850706590924810p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849100p -0.3
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849110p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849600p 0.9
+ 688817672049562767979945707026052520728098467412004369291611940262227750922939556896858064683824836325407170681804400077495059541709497340163918742768573954395708961038484347831666585753669047238523071698374733110710270339485431494539376029999787981701413181849610p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698700p -0.3
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363698710p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699200p 0.9
+ 1377635344099125535959891414052105041456196934824008738583223880524455501845879113793716129367649672650814341363608800154990119083418994680327837485537147908791417922076968695663333171507338094477046143396749466221420540678970862989078752059999575963402826363699210p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397900p -0.3
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727397910p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398400p 0.9
+ 2755270688198251071919782828104210082912393869648017477166447761048911003691758227587432258735299345301628682727217600309980238166837989360655674971074295817582835844153937391326666343014676188954092286793498932442841081357941725978157504119999151926805652727398410p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796300p -0.3
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796310p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796800p 0.9
+ 5510541376396502143839565656208420165824787739296034954332895522097822007383516455174864517470598690603257365454435200619960476333675978721311349942148591635165671688307874782653332686029352377908184573586997864885682162715883451956315008239998303853611305454796810p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593100p -0.3
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593110p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593600p 0.9
+ 11021082752793004287679131312416840331649575478592069908665791044195644014767032910349729034941197381206514730908870401239920952667351957442622699884297183270331343376615749565306665372058704755816369147173995729771364325431766903912630016479996607707222610909593610p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186700p -0.3
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819186710p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187200p 0.9
+ 22042165505586008575358262624833680663299150957184139817331582088391288029534065820699458069882394762413029461817740802479841905334703914885245399768594366540662686753231499130613330744117409511632738294347991459542728650863533807825260032959993215414445221819187210p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373900p -0.3
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638373910p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374400p 0.9
+ 44084331011172017150716525249667361326598301914368279634663164176782576059068131641398916139764789524826058923635481604959683810669407829770490799537188733081325373506462998261226661488234819023265476588695982919085457301727067615650520065919986430828890443638374410p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748300p -0.3
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748310p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748800p 0.9
+ 88168662022344034301433050499334722653196603828736559269326328353565152118136263282797832279529579049652117847270963209919367621338815659540981599074377466162650747012925996522453322976469638046530953177391965838170914603454135231301040131839972861657780887276748810p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497100p -0.3
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497110p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497600p 0.9
+ 176337324044688068602866100998669445306393207657473118538652656707130304236272526565595664559059158099304235694541926419838735242677631319081963198148754932325301494025851993044906645952939276093061906354783931676341829206908270462602080263679945723315561774553497610p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994700p -0.3
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106994710p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995200p 0.9
+ 352674648089376137205732201997338890612786415314946237077305313414260608472545053131191329118118316198608471389083852839677470485355262638163926396297509864650602988051703986089813291905878552186123812709567863352683658413816540925204160527359891446631123549106995210p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989900p -0.3
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213989910p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990400p 0.9
+ 705349296178752274411464403994677781225572830629892474154610626828521216945090106262382658236236632397216942778167705679354940970710525276327852792595019729301205976103407972179626583811757104372247625419135726705367316827633081850408321054719782893262247098213990410p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980300p -0.3
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980310p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980800p 0.9
+ 1410698592357504548822928807989355562451145661259784948309221253657042433890180212524765316472473264794433885556335411358709881941421050552655705585190039458602411952206815944359253167623514208744495250838271453410734633655266163700816642109439565786524494196427980810p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961100p -0.3
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961110p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961600p 0.9
+ 2821397184715009097645857615978711124902291322519569896618442507314084867780360425049530632944946529588867771112670822717419763882842101105311411170380078917204823904413631888718506335247028417488990501676542906821469267310532327401633284218879131573048988392855961610p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922700p -0.3
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711922710p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923200p 0.9
+ 5642794369430018195291715231957422249804582645039139793236885014628169735560720850099061265889893059177735542225341645434839527765684202210622822340760157834409647808827263777437012670494056834977981003353085813642938534621064654803266568437758263146097976785711923210p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845900p -0.3
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423845910p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846400p 0.9
+ 11285588738860036390583430463914844499609165290078279586473770029256339471121441700198122531779786118355471084450683290869679055531368404421245644681520315668819295617654527554874025340988113669955962006706171627285877069242129309606533136875516526292195953571423846410p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692300p -0.3
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692310p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692800p 0.9
+ 22571177477720072781166860927829688999218330580156559172947540058512678942242883400396245063559572236710942168901366581739358111062736808842491289363040631337638591235309055109748050681976227339911924013412343254571754138484258619213066273751033052584391907142847692810p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385100p -0.3
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385110p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385600p 0.9
+ 45142354955440145562333721855659377998436661160313118345895080117025357884485766800792490127119144473421884337802733163478716222125473617684982578726081262675277182470618110219496101363952454679823848026824686509143508276968517238426132547502066105168783814285695385610p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770700p -0.3
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390770710p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771200p 0.9
+ 90284709910880291124667443711318755996873322320626236691790160234050715768971533601584980254238288946843768675605466326957432444250947235369965157452162525350554364941236220438992202727904909359647696053649373018287016553937034476852265095004132210337567628571390771210p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541900p -0.3
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781541910p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542400p 0.9
+ 180569419821760582249334887422637511993746644641252473383580320468101431537943067203169960508476577893687537351210932653914864888501894470739930314904325050701108729882472440877984405455809818719295392107298746036574033107874068953704530190008264420675135257142781542410p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084300p -0.3
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084310p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084800p 0.9
+ 361138839643521164498669774845275023987493289282504946767160640936202863075886134406339921016953155787375074702421865307829729777003788941479860629808650101402217459764944881755968810911619637438590784214597492073148066215748137907409060380016528841350270514285563084810p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169100p -0.3
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169110p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169600p 0.9
+ 722277679287042328997339549690550047974986578565009893534321281872405726151772268812679842033906311574750149404843730615659459554007577882959721259617300202804434919529889763511937621823239274877181568429194984146296132431496275814818120760033057682700541028571126169610p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338700p -0.3
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252338710p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339200p 0.9
+ 1444555358574084657994679099381100095949973157130019787068642563744811452303544537625359684067812623149500298809687461231318919108015155765919442519234600405608869839059779527023875243646478549754363136858389968292592264862992551629636241520066115365401082057142252339210p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677900p -0.3
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504677910p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678400p 0.9
+ 2889110717148169315989358198762200191899946314260039574137285127489622904607089075250719368135625246299000597619374922462637838216030311531838885038469200811217739678119559054047750487292957099508726273716779936585184529725985103259272483040132230730802164114284504678410p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356300p -0.3
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356310p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356800p 0.9
+ 5778221434296338631978716397524400383799892628520079148274570254979245809214178150501438736271250492598001195238749844925275676432060623063677770076938401622435479356239118108095500974585914199017452547433559873170369059451970206518544966080264461461604328228569009356810p -0.3
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713100p -0.3
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713110p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713600p 0.9
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713610p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426700p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426710p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427200p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427210p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853900p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853910p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854400p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854410p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708300p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708310p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708800p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708810p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417100p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417110p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417600p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417610p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834700p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834710p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835200p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835210p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669900p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669910p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670400p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670410p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340300p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340310p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340800p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340810p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681100p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681110p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681600p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681610p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362700p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362710p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363200p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363210p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725900p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725910p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726400p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726410p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452300p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452310p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452800p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452810p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905100p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905110p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905600p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905610p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810700p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810710p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811200p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811210p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621900p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621910p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622400p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622410p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244300p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244310p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244800p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244810p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489100p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489110p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489600p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489610p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978700p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978710p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979200p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979210p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957900p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957910p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958400p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958410p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916300p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916310p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916800p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916810p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833100p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833110p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833600p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833610p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666700p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666710p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667200p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667210p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333900p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333910p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334400p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334410p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668300p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668310p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668800p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668810p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337100p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337110p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337600p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337610p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674700p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674710p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675200p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675210p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349900p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349910p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350400p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350410p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700300p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700310p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700800p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700810p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401100p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401110p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401600p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401610p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802700p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802710p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803200p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803210p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605900p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605910p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606400p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606410p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212300p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212310p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212800p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212810p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425100p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425110p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425600p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425610p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850700p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850710p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851200p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851210p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701900p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701910p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702400p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702410p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404300p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404310p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404800p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404810p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809100p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809110p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809600p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809610p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618700p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618710p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619200p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619210p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237900p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237910p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238400p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238410p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476300p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476310p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476800p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476810p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953100p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953110p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953600p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953610p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906700p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906710p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907200p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907210p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813900p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813910p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814400p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814410p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628300p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628310p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628800p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628810p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257100p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257110p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257600p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257610p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514700p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514710p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515200p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515210p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029900p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029910p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030400p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030410p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060300p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060310p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060800p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060810p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121100p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121110p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121600p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121610p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242700p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242710p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243200p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243210p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485900p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485910p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486400p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486410p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972300p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972310p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972800p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972810p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945100p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945110p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945600p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945610p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890700p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890710p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891200p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891210p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781900p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781910p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782400p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782410p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564300p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564310p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564800p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564810p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129100p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129110p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129600p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129610p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258700p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258710p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259200p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259210p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517900p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517910p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518400p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518410p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036300p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036310p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036800p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036810p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073100p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073110p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073600p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073610p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146700p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146710p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147200p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147210p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293900p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293910p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294400p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294410p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588300p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588310p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588800p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588810p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177100p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177110p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177600p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177610p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354700p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354710p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355200p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355210p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709900p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709910p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710400p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710410p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420300p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420310p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420800p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420810p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841100p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841110p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841600p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841610p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682700p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682710p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683200p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683210p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365900p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365910p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366400p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366410p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732300p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732310p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732800p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732810p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465100p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465110p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465600p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465610p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930700p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930710p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931200p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931210p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861900p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861910p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862400p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862410p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724300p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724310p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724800p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724810p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449100p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449110p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449600p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449610p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898700p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898710p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899200p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899210p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797900p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797910p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798400p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798410p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596300p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596310p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596800p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596810p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193100p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193110p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193600p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193610p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386700p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386710p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387200p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387210p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773900p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773910p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774400p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774410p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548300p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548310p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548800p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548810p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097100p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097110p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097600p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097610p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194700p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194710p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195200p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195210p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389900p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389910p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390400p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390410p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780300p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780310p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780800p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780810p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561100p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561110p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561600p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561610p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122700p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122710p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123200p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123210p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245900p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245910p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246400p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246410p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492300p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492310p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492800p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492810p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985100p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985110p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985600p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985610p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970700p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970710p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971200p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971210p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941900p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941910p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942400p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942410p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884300p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884310p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884800p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884810p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769100p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769110p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769600p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769610p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538700p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538710p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539200p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539210p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077900p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077910p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078400p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078410p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156300p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156310p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156800p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156810p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313100p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313110p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313600p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313610p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626700p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626710p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627200p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627210p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253900p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253910p 0.9
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254400p 0.9
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254410p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508300p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508310p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508800p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508810p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017100p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017110p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017600p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017610p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034700p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034710p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035200p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035210p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069900p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069910p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070400p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070410p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140300p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140310p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140800p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140810p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281100p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281110p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281600p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281610p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562700p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562710p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563200p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563210p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125900p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125910p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126400p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126410p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252300p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252310p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252800p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252810p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505100p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505110p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505600p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505610p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010700p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010710p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011200p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011210p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021900p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021910p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022400p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022410p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044300p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044310p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044800p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044810p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089100p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089110p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089600p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089610p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178700p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178710p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179200p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179210p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357900p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357910p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358400p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358410p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716300p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716310p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716800p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716810p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433100p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433110p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433600p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433610p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866700p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866710p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867200p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867210p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733900p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733910p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734400p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734410p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468300p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468310p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468800p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468810p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937100p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937110p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937600p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937610p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874700p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874710p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875200p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875210p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749900p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749910p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750400p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750410p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500300p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500310p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500800p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500810p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001100p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001110p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001600p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001610p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002700p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002710p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003200p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003210p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005900p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005910p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006400p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006410p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012300p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012310p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012800p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012810p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025100p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025110p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025600p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025610p -0.3
+ \]
V_RW_bar   (RW_bar gnd!)     vsource type=pwl wave=\[
+ 0    0.9
+ 200p 0.9
+ 210p -0.3
+ 700p -0.3
+ 710p 0.9
+ 900p 0.9
+ 910p -0.3
+ 1400p -0.3
+ 1410p 0.9
+ 2300p 0.9
+ 2310p -0.3
+ 2800p -0.3
+ 2810p 0.9
+ 5100p 0.9
+ 5110p -0.3
+ 5600p -0.3
+ 5610p 0.9
+ 10700p 0.9
+ 10710p -0.3
+ 11200p -0.3
+ 11210p 0.9
+ 21900p 0.9
+ 21910p -0.3
+ 22400p -0.3
+ 22410p 0.9
+ 44300p 0.9
+ 44310p -0.3
+ 44800p -0.3
+ 44810p 0.9
+ 89100p 0.9
+ 89110p -0.3
+ 89600p -0.3
+ 89610p 0.9
+ 178700p 0.9
+ 178710p -0.3
+ 179200p -0.3
+ 179210p 0.9
+ 357900p 0.9
+ 357910p -0.3
+ 358400p -0.3
+ 358410p 0.9
+ 716300p 0.9
+ 716310p -0.3
+ 716800p -0.3
+ 716810p 0.9
+ 1433100p 0.9
+ 1433110p -0.3
+ 1433600p -0.3
+ 1433610p 0.9
+ 2866700p 0.9
+ 2866710p -0.3
+ 2867200p -0.3
+ 2867210p 0.9
+ 5733900p 0.9
+ 5733910p -0.3
+ 5734400p -0.3
+ 5734410p 0.9
+ 11468300p 0.9
+ 11468310p -0.3
+ 11468800p -0.3
+ 11468810p 0.9
+ 22937100p 0.9
+ 22937110p -0.3
+ 22937600p -0.3
+ 22937610p 0.9
+ 45874700p 0.9
+ 45874710p -0.3
+ 45875200p -0.3
+ 45875210p 0.9
+ 91749900p 0.9
+ 91749910p -0.3
+ 91750400p -0.3
+ 91750410p 0.9
+ 183500300p 0.9
+ 183500310p -0.3
+ 183500800p -0.3
+ 183500810p 0.9
+ 367001100p 0.9
+ 367001110p -0.3
+ 367001600p -0.3
+ 367001610p 0.9
+ 734002700p 0.9
+ 734002710p -0.3
+ 734003200p -0.3
+ 734003210p 0.9
+ 1468005900p 0.9
+ 1468005910p -0.3
+ 1468006400p -0.3
+ 1468006410p 0.9
+ 2936012300p 0.9
+ 2936012310p -0.3
+ 2936012800p -0.3
+ 2936012810p 0.9
+ 5872025100p 0.9
+ 5872025110p -0.3
+ 5872025600p -0.3
+ 5872025610p 0.9
+ 11744050700p 0.9
+ 11744050710p -0.3
+ 11744051200p -0.3
+ 11744051210p 0.9
+ 23488101900p 0.9
+ 23488101910p -0.3
+ 23488102400p -0.3
+ 23488102410p 0.9
+ 46976204300p 0.9
+ 46976204310p -0.3
+ 46976204800p -0.3
+ 46976204810p 0.9
+ 93952409100p 0.9
+ 93952409110p -0.3
+ 93952409600p -0.3
+ 93952409610p 0.9
+ 187904818700p 0.9
+ 187904818710p -0.3
+ 187904819200p -0.3
+ 187904819210p 0.9
+ 375809637900p 0.9
+ 375809637910p -0.3
+ 375809638400p -0.3
+ 375809638410p 0.9
+ 751619276300p 0.9
+ 751619276310p -0.3
+ 751619276800p -0.3
+ 751619276810p 0.9
+ 1503238553100p 0.9
+ 1503238553110p -0.3
+ 1503238553600p -0.3
+ 1503238553610p 0.9
+ 3006477106700p 0.9
+ 3006477106710p -0.3
+ 3006477107200p -0.3
+ 3006477107210p 0.9
+ 6012954213900p 0.9
+ 6012954213910p -0.3
+ 6012954214400p -0.3
+ 6012954214410p 0.9
+ 12025908428300p 0.9
+ 12025908428310p -0.3
+ 12025908428800p -0.3
+ 12025908428810p 0.9
+ 24051816857100p 0.9
+ 24051816857110p -0.3
+ 24051816857600p -0.3
+ 24051816857610p 0.9
+ 48103633714700p 0.9
+ 48103633714710p -0.3
+ 48103633715200p -0.3
+ 48103633715210p 0.9
+ 96207267429900p 0.9
+ 96207267429910p -0.3
+ 96207267430400p -0.3
+ 96207267430410p 0.9
+ 192414534860300p 0.9
+ 192414534860310p -0.3
+ 192414534860800p -0.3
+ 192414534860810p 0.9
+ 384829069721100p 0.9
+ 384829069721110p -0.3
+ 384829069721600p -0.3
+ 384829069721610p 0.9
+ 769658139442700p 0.9
+ 769658139442710p -0.3
+ 769658139443200p -0.3
+ 769658139443210p 0.9
+ 1539316278885900p 0.9
+ 1539316278885910p -0.3
+ 1539316278886400p -0.3
+ 1539316278886410p 0.9
+ 3078632557772300p 0.9
+ 3078632557772310p -0.3
+ 3078632557772800p -0.3
+ 3078632557772810p 0.9
+ 6157265115545100p 0.9
+ 6157265115545110p -0.3
+ 6157265115545600p -0.3
+ 6157265115545610p 0.9
+ 12314530231090700p 0.9
+ 12314530231090710p -0.3
+ 12314530231091200p -0.3
+ 12314530231091210p 0.9
+ 24629060462181900p 0.9
+ 24629060462181910p -0.3
+ 24629060462182400p -0.3
+ 24629060462182410p 0.9
+ 49258120924364300p 0.9
+ 49258120924364310p -0.3
+ 49258120924364800p -0.3
+ 49258120924364810p 0.9
+ 98516241848729100p 0.9
+ 98516241848729110p -0.3
+ 98516241848729600p -0.3
+ 98516241848729610p 0.9
+ 197032483697458700p 0.9
+ 197032483697458710p -0.3
+ 197032483697459200p -0.3
+ 197032483697459210p 0.9
+ 394064967394917900p 0.9
+ 394064967394917910p -0.3
+ 394064967394918400p -0.3
+ 394064967394918410p 0.9
+ 788129934789836300p 0.9
+ 788129934789836310p -0.3
+ 788129934789836800p -0.3
+ 788129934789836810p 0.9
+ 1576259869579673100p 0.9
+ 1576259869579673110p -0.3
+ 1576259869579673600p -0.3
+ 1576259869579673610p 0.9
+ 3152519739159346700p 0.9
+ 3152519739159346710p -0.3
+ 3152519739159347200p -0.3
+ 3152519739159347210p 0.9
+ 6305039478318693900p 0.9
+ 6305039478318693910p -0.3
+ 6305039478318694400p -0.3
+ 6305039478318694410p 0.9
+ 12610078956637388300p 0.9
+ 12610078956637388310p -0.3
+ 12610078956637388800p -0.3
+ 12610078956637388810p 0.9
+ 25220157913274777100p 0.9
+ 25220157913274777110p -0.3
+ 25220157913274777600p -0.3
+ 25220157913274777610p 0.9
+ 50440315826549554700p 0.9
+ 50440315826549554710p -0.3
+ 50440315826549555200p -0.3
+ 50440315826549555210p 0.9
+ 100880631653099109900p 0.9
+ 100880631653099109910p -0.3
+ 100880631653099110400p -0.3
+ 100880631653099110410p 0.9
+ 201761263306198220300p 0.9
+ 201761263306198220310p -0.3
+ 201761263306198220800p -0.3
+ 201761263306198220810p 0.9
+ 403522526612396441100p 0.9
+ 403522526612396441110p -0.3
+ 403522526612396441600p -0.3
+ 403522526612396441610p 0.9
+ 807045053224792882700p 0.9
+ 807045053224792882710p -0.3
+ 807045053224792883200p -0.3
+ 807045053224792883210p 0.9
+ 1614090106449585765900p 0.9
+ 1614090106449585765910p -0.3
+ 1614090106449585766400p -0.3
+ 1614090106449585766410p 0.9
+ 3228180212899171532300p 0.9
+ 3228180212899171532310p -0.3
+ 3228180212899171532800p -0.3
+ 3228180212899171532810p 0.9
+ 6456360425798343065100p 0.9
+ 6456360425798343065110p -0.3
+ 6456360425798343065600p -0.3
+ 6456360425798343065610p 0.9
+ 12912720851596686130700p 0.9
+ 12912720851596686130710p -0.3
+ 12912720851596686131200p -0.3
+ 12912720851596686131210p 0.9
+ 25825441703193372261900p 0.9
+ 25825441703193372261910p -0.3
+ 25825441703193372262400p -0.3
+ 25825441703193372262410p 0.9
+ 51650883406386744524300p 0.9
+ 51650883406386744524310p -0.3
+ 51650883406386744524800p -0.3
+ 51650883406386744524810p 0.9
+ 103301766812773489049100p 0.9
+ 103301766812773489049110p -0.3
+ 103301766812773489049600p -0.3
+ 103301766812773489049610p 0.9
+ 206603533625546978098700p 0.9
+ 206603533625546978098710p -0.3
+ 206603533625546978099200p -0.3
+ 206603533625546978099210p 0.9
+ 413207067251093956197900p 0.9
+ 413207067251093956197910p -0.3
+ 413207067251093956198400p -0.3
+ 413207067251093956198410p 0.9
+ 826414134502187912396300p 0.9
+ 826414134502187912396310p -0.3
+ 826414134502187912396800p -0.3
+ 826414134502187912396810p 0.9
+ 1652828269004375824793100p 0.9
+ 1652828269004375824793110p -0.3
+ 1652828269004375824793600p -0.3
+ 1652828269004375824793610p 0.9
+ 3305656538008751649586700p 0.9
+ 3305656538008751649586710p -0.3
+ 3305656538008751649587200p -0.3
+ 3305656538008751649587210p 0.9
+ 6611313076017503299173900p 0.9
+ 6611313076017503299173910p -0.3
+ 6611313076017503299174400p -0.3
+ 6611313076017503299174410p 0.9
+ 13222626152035006598348300p 0.9
+ 13222626152035006598348310p -0.3
+ 13222626152035006598348800p -0.3
+ 13222626152035006598348810p 0.9
+ 26445252304070013196697100p 0.9
+ 26445252304070013196697110p -0.3
+ 26445252304070013196697600p -0.3
+ 26445252304070013196697610p 0.9
+ 52890504608140026393394700p 0.9
+ 52890504608140026393394710p -0.3
+ 52890504608140026393395200p -0.3
+ 52890504608140026393395210p 0.9
+ 105781009216280052786789900p 0.9
+ 105781009216280052786789910p -0.3
+ 105781009216280052786790400p -0.3
+ 105781009216280052786790410p 0.9
+ 211562018432560105573580300p 0.9
+ 211562018432560105573580310p -0.3
+ 211562018432560105573580800p -0.3
+ 211562018432560105573580810p 0.9
+ 423124036865120211147161100p 0.9
+ 423124036865120211147161110p -0.3
+ 423124036865120211147161600p -0.3
+ 423124036865120211147161610p 0.9
+ 846248073730240422294322700p 0.9
+ 846248073730240422294322710p -0.3
+ 846248073730240422294323200p -0.3
+ 846248073730240422294323210p 0.9
+ 1692496147460480844588645900p 0.9
+ 1692496147460480844588645910p -0.3
+ 1692496147460480844588646400p -0.3
+ 1692496147460480844588646410p 0.9
+ 3384992294920961689177292300p 0.9
+ 3384992294920961689177292310p -0.3
+ 3384992294920961689177292800p -0.3
+ 3384992294920961689177292810p 0.9
+ 6769984589841923378354585100p 0.9
+ 6769984589841923378354585110p -0.3
+ 6769984589841923378354585600p -0.3
+ 6769984589841923378354585610p 0.9
+ 13539969179683846756709170700p 0.9
+ 13539969179683846756709170710p -0.3
+ 13539969179683846756709171200p -0.3
+ 13539969179683846756709171210p 0.9
+ 27079938359367693513418341900p 0.9
+ 27079938359367693513418341910p -0.3
+ 27079938359367693513418342400p -0.3
+ 27079938359367693513418342410p 0.9
+ 54159876718735387026836684300p 0.9
+ 54159876718735387026836684310p -0.3
+ 54159876718735387026836684800p -0.3
+ 54159876718735387026836684810p 0.9
+ 108319753437470774053673369100p 0.9
+ 108319753437470774053673369110p -0.3
+ 108319753437470774053673369600p -0.3
+ 108319753437470774053673369610p 0.9
+ 216639506874941548107346738700p 0.9
+ 216639506874941548107346738710p -0.3
+ 216639506874941548107346739200p -0.3
+ 216639506874941548107346739210p 0.9
+ 433279013749883096214693477900p 0.9
+ 433279013749883096214693477910p -0.3
+ 433279013749883096214693478400p -0.3
+ 433279013749883096214693478410p 0.9
+ 866558027499766192429386956300p 0.9
+ 866558027499766192429386956310p -0.3
+ 866558027499766192429386956800p -0.3
+ 866558027499766192429386956810p 0.9
+ 1733116054999532384858773913100p 0.9
+ 1733116054999532384858773913110p -0.3
+ 1733116054999532384858773913600p -0.3
+ 1733116054999532384858773913610p 0.9
+ 3466232109999064769717547826700p 0.9
+ 3466232109999064769717547826710p -0.3
+ 3466232109999064769717547827200p -0.3
+ 3466232109999064769717547827210p 0.9
+ 6932464219998129539435095653900p 0.9
+ 6932464219998129539435095653910p -0.3
+ 6932464219998129539435095654400p -0.3
+ 6932464219998129539435095654410p 0.9
+ 13864928439996259078870191308300p 0.9
+ 13864928439996259078870191308310p -0.3
+ 13864928439996259078870191308800p -0.3
+ 13864928439996259078870191308810p 0.9
+ 27729856879992518157740382617100p 0.9
+ 27729856879992518157740382617110p -0.3
+ 27729856879992518157740382617600p -0.3
+ 27729856879992518157740382617610p 0.9
+ 55459713759985036315480765234700p 0.9
+ 55459713759985036315480765234710p -0.3
+ 55459713759985036315480765235200p -0.3
+ 55459713759985036315480765235210p 0.9
+ 110919427519970072630961530469900p 0.9
+ 110919427519970072630961530469910p -0.3
+ 110919427519970072630961530470400p -0.3
+ 110919427519970072630961530470410p 0.9
+ 221838855039940145261923060940300p 0.9
+ 221838855039940145261923060940310p -0.3
+ 221838855039940145261923060940800p -0.3
+ 221838855039940145261923060940810p 0.9
+ 443677710079880290523846121881100p 0.9
+ 443677710079880290523846121881110p -0.3
+ 443677710079880290523846121881600p -0.3
+ 443677710079880290523846121881610p 0.9
+ 887355420159760581047692243762700p 0.9
+ 887355420159760581047692243762710p -0.3
+ 887355420159760581047692243763200p -0.3
+ 887355420159760581047692243763210p 0.9
+ 1774710840319521162095384487525900p 0.9
+ 1774710840319521162095384487525910p -0.3
+ 1774710840319521162095384487526400p -0.3
+ 1774710840319521162095384487526410p 0.9
+ 3549421680639042324190768975052300p 0.9
+ 3549421680639042324190768975052310p -0.3
+ 3549421680639042324190768975052800p -0.3
+ 3549421680639042324190768975052810p 0.9
+ 7098843361278084648381537950105100p 0.9
+ 7098843361278084648381537950105110p -0.3
+ 7098843361278084648381537950105600p -0.3
+ 7098843361278084648381537950105610p 0.9
+ 14197686722556169296763075900210700p 0.9
+ 14197686722556169296763075900210710p -0.3
+ 14197686722556169296763075900211200p -0.3
+ 14197686722556169296763075900211210p 0.9
+ 28395373445112338593526151800421900p 0.9
+ 28395373445112338593526151800421910p -0.3
+ 28395373445112338593526151800422400p -0.3
+ 28395373445112338593526151800422410p 0.9
+ 56790746890224677187052303600844300p 0.9
+ 56790746890224677187052303600844310p -0.3
+ 56790746890224677187052303600844800p -0.3
+ 56790746890224677187052303600844810p 0.9
+ 113581493780449354374104607201689100p 0.9
+ 113581493780449354374104607201689110p -0.3
+ 113581493780449354374104607201689600p -0.3
+ 113581493780449354374104607201689610p 0.9
+ 227162987560898708748209214403378700p 0.9
+ 227162987560898708748209214403378710p -0.3
+ 227162987560898708748209214403379200p -0.3
+ 227162987560898708748209214403379210p 0.9
+ 454325975121797417496418428806757900p 0.9
+ 454325975121797417496418428806757910p -0.3
+ 454325975121797417496418428806758400p -0.3
+ 454325975121797417496418428806758410p 0.9
+ 908651950243594834992836857613516300p 0.9
+ 908651950243594834992836857613516310p -0.3
+ 908651950243594834992836857613516800p -0.3
+ 908651950243594834992836857613516810p 0.9
+ 1817303900487189669985673715227033100p 0.9
+ 1817303900487189669985673715227033110p -0.3
+ 1817303900487189669985673715227033600p -0.3
+ 1817303900487189669985673715227033610p 0.9
+ 3634607800974379339971347430454066700p 0.9
+ 3634607800974379339971347430454066710p -0.3
+ 3634607800974379339971347430454067200p -0.3
+ 3634607800974379339971347430454067210p 0.9
+ 7269215601948758679942694860908133900p 0.9
+ 7269215601948758679942694860908133910p -0.3
+ 7269215601948758679942694860908134400p -0.3
+ 7269215601948758679942694860908134410p 0.9
+ 14538431203897517359885389721816268300p 0.9
+ 14538431203897517359885389721816268310p -0.3
+ 14538431203897517359885389721816268800p -0.3
+ 14538431203897517359885389721816268810p 0.9
+ 29076862407795034719770779443632537100p 0.9
+ 29076862407795034719770779443632537110p -0.3
+ 29076862407795034719770779443632537600p -0.3
+ 29076862407795034719770779443632537610p 0.9
+ 58153724815590069439541558887265074700p 0.9
+ 58153724815590069439541558887265074710p -0.3
+ 58153724815590069439541558887265075200p -0.3
+ 58153724815590069439541558887265075210p 0.9
+ 116307449631180138879083117774530149900p 0.9
+ 116307449631180138879083117774530149910p -0.3
+ 116307449631180138879083117774530150400p -0.3
+ 116307449631180138879083117774530150410p 0.9
+ 232614899262360277758166235549060300300p 0.9
+ 232614899262360277758166235549060300310p -0.3
+ 232614899262360277758166235549060300800p -0.3
+ 232614899262360277758166235549060300810p 0.9
+ 465229798524720555516332471098120601100p 0.9
+ 465229798524720555516332471098120601110p -0.3
+ 465229798524720555516332471098120601600p -0.3
+ 465229798524720555516332471098120601610p 0.9
+ 930459597049441111032664942196241202700p 0.9
+ 930459597049441111032664942196241202710p -0.3
+ 930459597049441111032664942196241203200p -0.3
+ 930459597049441111032664942196241203210p 0.9
+ 1860919194098882222065329884392482405900p 0.9
+ 1860919194098882222065329884392482405910p -0.3
+ 1860919194098882222065329884392482406400p -0.3
+ 1860919194098882222065329884392482406410p 0.9
+ 3721838388197764444130659768784964812300p 0.9
+ 3721838388197764444130659768784964812310p -0.3
+ 3721838388197764444130659768784964812800p -0.3
+ 3721838388197764444130659768784964812810p 0.9
+ 7443676776395528888261319537569929625100p 0.9
+ 7443676776395528888261319537569929625110p -0.3
+ 7443676776395528888261319537569929625600p -0.3
+ 7443676776395528888261319537569929625610p 0.9
+ 14887353552791057776522639075139859250700p 0.9
+ 14887353552791057776522639075139859250710p -0.3
+ 14887353552791057776522639075139859251200p -0.3
+ 14887353552791057776522639075139859251210p 0.9
+ 29774707105582115553045278150279718501900p 0.9
+ 29774707105582115553045278150279718501910p -0.3
+ 29774707105582115553045278150279718502400p -0.3
+ 29774707105582115553045278150279718502410p 0.9
+ 59549414211164231106090556300559437004300p 0.9
+ 59549414211164231106090556300559437004310p -0.3
+ 59549414211164231106090556300559437004800p -0.3
+ 59549414211164231106090556300559437004810p 0.9
+ 119098828422328462212181112601118874009100p 0.9
+ 119098828422328462212181112601118874009110p -0.3
+ 119098828422328462212181112601118874009600p -0.3
+ 119098828422328462212181112601118874009610p 0.9
+ 238197656844656924424362225202237748018700p 0.9
+ 238197656844656924424362225202237748018710p -0.3
+ 238197656844656924424362225202237748019200p -0.3
+ 238197656844656924424362225202237748019210p 0.9
+ 476395313689313848848724450404475496037900p 0.9
+ 476395313689313848848724450404475496037910p -0.3
+ 476395313689313848848724450404475496038400p -0.3
+ 476395313689313848848724450404475496038410p 0.9
+ 952790627378627697697448900808950992076300p 0.9
+ 952790627378627697697448900808950992076310p -0.3
+ 952790627378627697697448900808950992076800p -0.3
+ 952790627378627697697448900808950992076810p 0.9
+ 1905581254757255395394897801617901984153100p 0.9
+ 1905581254757255395394897801617901984153110p -0.3
+ 1905581254757255395394897801617901984153600p -0.3
+ 1905581254757255395394897801617901984153610p 0.9
+ 3811162509514510790789795603235803968306700p 0.9
+ 3811162509514510790789795603235803968306710p -0.3
+ 3811162509514510790789795603235803968307200p -0.3
+ 3811162509514510790789795603235803968307210p 0.9
+ 7622325019029021581579591206471607936613900p 0.9
+ 7622325019029021581579591206471607936613910p -0.3
+ 7622325019029021581579591206471607936614400p -0.3
+ 7622325019029021581579591206471607936614410p 0.9
+ 15244650038058043163159182412943215873228300p 0.9
+ 15244650038058043163159182412943215873228310p -0.3
+ 15244650038058043163159182412943215873228800p -0.3
+ 15244650038058043163159182412943215873228810p 0.9
+ 30489300076116086326318364825886431746457100p 0.9
+ 30489300076116086326318364825886431746457110p -0.3
+ 30489300076116086326318364825886431746457600p -0.3
+ 30489300076116086326318364825886431746457610p 0.9
+ 60978600152232172652636729651772863492914700p 0.9
+ 60978600152232172652636729651772863492914710p -0.3
+ 60978600152232172652636729651772863492915200p -0.3
+ 60978600152232172652636729651772863492915210p 0.9
+ 121957200304464345305273459303545726985829900p 0.9
+ 121957200304464345305273459303545726985829910p -0.3
+ 121957200304464345305273459303545726985830400p -0.3
+ 121957200304464345305273459303545726985830410p 0.9
+ 243914400608928690610546918607091453971660300p 0.9
+ 243914400608928690610546918607091453971660310p -0.3
+ 243914400608928690610546918607091453971660800p -0.3
+ 243914400608928690610546918607091453971660810p 0.9
+ 487828801217857381221093837214182907943321100p 0.9
+ 487828801217857381221093837214182907943321110p -0.3
+ 487828801217857381221093837214182907943321600p -0.3
+ 487828801217857381221093837214182907943321610p 0.9
+ 975657602435714762442187674428365815886642700p 0.9
+ 975657602435714762442187674428365815886642710p -0.3
+ 975657602435714762442187674428365815886643200p -0.3
+ 975657602435714762442187674428365815886643210p 0.9
+ 1951315204871429524884375348856731631773285900p 0.9
+ 1951315204871429524884375348856731631773285910p -0.3
+ 1951315204871429524884375348856731631773286400p -0.3
+ 1951315204871429524884375348856731631773286410p 0.9
+ 3902630409742859049768750697713463263546572300p 0.9
+ 3902630409742859049768750697713463263546572310p -0.3
+ 3902630409742859049768750697713463263546572800p -0.3
+ 3902630409742859049768750697713463263546572810p 0.9
+ 7805260819485718099537501395426926527093145100p 0.9
+ 7805260819485718099537501395426926527093145110p -0.3
+ 7805260819485718099537501395426926527093145600p -0.3
+ 7805260819485718099537501395426926527093145610p 0.9
+ 15610521638971436199075002790853853054186290700p 0.9
+ 15610521638971436199075002790853853054186290710p -0.3
+ 15610521638971436199075002790853853054186291200p -0.3
+ 15610521638971436199075002790853853054186291210p 0.9
+ 31221043277942872398150005581707706108372581900p 0.9
+ 31221043277942872398150005581707706108372581910p -0.3
+ 31221043277942872398150005581707706108372582400p -0.3
+ 31221043277942872398150005581707706108372582410p 0.9
+ 62442086555885744796300011163415412216745164300p 0.9
+ 62442086555885744796300011163415412216745164310p -0.3
+ 62442086555885744796300011163415412216745164800p -0.3
+ 62442086555885744796300011163415412216745164810p 0.9
+ 124884173111771489592600022326830824433490329100p 0.9
+ 124884173111771489592600022326830824433490329110p -0.3
+ 124884173111771489592600022326830824433490329600p -0.3
+ 124884173111771489592600022326830824433490329610p 0.9
+ 249768346223542979185200044653661648866980658700p 0.9
+ 249768346223542979185200044653661648866980658710p -0.3
+ 249768346223542979185200044653661648866980659200p -0.3
+ 249768346223542979185200044653661648866980659210p 0.9
+ 499536692447085958370400089307323297733961317900p 0.9
+ 499536692447085958370400089307323297733961317910p -0.3
+ 499536692447085958370400089307323297733961318400p -0.3
+ 499536692447085958370400089307323297733961318410p 0.9
+ 999073384894171916740800178614646595467922636300p 0.9
+ 999073384894171916740800178614646595467922636310p -0.3
+ 999073384894171916740800178614646595467922636800p -0.3
+ 999073384894171916740800178614646595467922636810p 0.9
+ 1998146769788343833481600357229293190935845273100p 0.9
+ 1998146769788343833481600357229293190935845273110p -0.3
+ 1998146769788343833481600357229293190935845273600p -0.3
+ 1998146769788343833481600357229293190935845273610p 0.9
+ 3996293539576687666963200714458586381871690546700p 0.9
+ 3996293539576687666963200714458586381871690546710p -0.3
+ 3996293539576687666963200714458586381871690547200p -0.3
+ 3996293539576687666963200714458586381871690547210p 0.9
+ 7992587079153375333926401428917172763743381093900p 0.9
+ 7992587079153375333926401428917172763743381093910p -0.3
+ 7992587079153375333926401428917172763743381094400p -0.3
+ 7992587079153375333926401428917172763743381094410p 0.9
+ 15985174158306750667852802857834345527486762188300p 0.9
+ 15985174158306750667852802857834345527486762188310p -0.3
+ 15985174158306750667852802857834345527486762188800p -0.3
+ 15985174158306750667852802857834345527486762188810p 0.9
+ 31970348316613501335705605715668691054973524377100p 0.9
+ 31970348316613501335705605715668691054973524377110p -0.3
+ 31970348316613501335705605715668691054973524377600p -0.3
+ 31970348316613501335705605715668691054973524377610p 0.9
+ 63940696633227002671411211431337382109947048754700p 0.9
+ 63940696633227002671411211431337382109947048754710p -0.3
+ 63940696633227002671411211431337382109947048755200p -0.3
+ 63940696633227002671411211431337382109947048755210p 0.9
+ 127881393266454005342822422862674764219894097509900p 0.9
+ 127881393266454005342822422862674764219894097509910p -0.3
+ 127881393266454005342822422862674764219894097510400p -0.3
+ 127881393266454005342822422862674764219894097510410p 0.9
+ 255762786532908010685644845725349528439788195020300p 0.9
+ 255762786532908010685644845725349528439788195020310p -0.3
+ 255762786532908010685644845725349528439788195020800p -0.3
+ 255762786532908010685644845725349528439788195020810p 0.9
+ 511525573065816021371289691450699056879576390041100p 0.9
+ 511525573065816021371289691450699056879576390041110p -0.3
+ 511525573065816021371289691450699056879576390041600p -0.3
+ 511525573065816021371289691450699056879576390041610p 0.9
+ 1023051146131632042742579382901398113759152780082700p 0.9
+ 1023051146131632042742579382901398113759152780082710p -0.3
+ 1023051146131632042742579382901398113759152780083200p -0.3
+ 1023051146131632042742579382901398113759152780083210p 0.9
+ 2046102292263264085485158765802796227518305560165900p 0.9
+ 2046102292263264085485158765802796227518305560165910p -0.3
+ 2046102292263264085485158765802796227518305560166400p -0.3
+ 2046102292263264085485158765802796227518305560166410p 0.9
+ 4092204584526528170970317531605592455036611120332300p 0.9
+ 4092204584526528170970317531605592455036611120332310p -0.3
+ 4092204584526528170970317531605592455036611120332800p -0.3
+ 4092204584526528170970317531605592455036611120332810p 0.9
+ 8184409169053056341940635063211184910073222240665100p 0.9
+ 8184409169053056341940635063211184910073222240665110p -0.3
+ 8184409169053056341940635063211184910073222240665600p -0.3
+ 8184409169053056341940635063211184910073222240665610p 0.9
+ 16368818338106112683881270126422369820146444481330700p 0.9
+ 16368818338106112683881270126422369820146444481330710p -0.3
+ 16368818338106112683881270126422369820146444481331200p -0.3
+ 16368818338106112683881270126422369820146444481331210p 0.9
+ 32737636676212225367762540252844739640292888962661900p 0.9
+ 32737636676212225367762540252844739640292888962661910p -0.3
+ 32737636676212225367762540252844739640292888962662400p -0.3
+ 32737636676212225367762540252844739640292888962662410p 0.9
+ 65475273352424450735525080505689479280585777925324300p 0.9
+ 65475273352424450735525080505689479280585777925324310p -0.3
+ 65475273352424450735525080505689479280585777925324800p -0.3
+ 65475273352424450735525080505689479280585777925324810p 0.9
+ 130950546704848901471050161011378958561171555850649100p 0.9
+ 130950546704848901471050161011378958561171555850649110p -0.3
+ 130950546704848901471050161011378958561171555850649600p -0.3
+ 130950546704848901471050161011378958561171555850649610p 0.9
+ 261901093409697802942100322022757917122343111701298700p 0.9
+ 261901093409697802942100322022757917122343111701298710p -0.3
+ 261901093409697802942100322022757917122343111701299200p -0.3
+ 261901093409697802942100322022757917122343111701299210p 0.9
+ 523802186819395605884200644045515834244686223402597900p 0.9
+ 523802186819395605884200644045515834244686223402597910p -0.3
+ 523802186819395605884200644045515834244686223402598400p -0.3
+ 523802186819395605884200644045515834244686223402598410p 0.9
+ 1047604373638791211768401288091031668489372446805196300p 0.9
+ 1047604373638791211768401288091031668489372446805196310p -0.3
+ 1047604373638791211768401288091031668489372446805196800p -0.3
+ 1047604373638791211768401288091031668489372446805196810p 0.9
+ 2095208747277582423536802576182063336978744893610393100p 0.9
+ 2095208747277582423536802576182063336978744893610393110p -0.3
+ 2095208747277582423536802576182063336978744893610393600p -0.3
+ 2095208747277582423536802576182063336978744893610393610p 0.9
+ 4190417494555164847073605152364126673957489787220786700p 0.9
+ 4190417494555164847073605152364126673957489787220786710p -0.3
+ 4190417494555164847073605152364126673957489787220787200p -0.3
+ 4190417494555164847073605152364126673957489787220787210p 0.9
+ 8380834989110329694147210304728253347914979574441573900p 0.9
+ 8380834989110329694147210304728253347914979574441573910p -0.3
+ 8380834989110329694147210304728253347914979574441574400p -0.3
+ 8380834989110329694147210304728253347914979574441574410p 0.9
+ 16761669978220659388294420609456506695829959148883148300p 0.9
+ 16761669978220659388294420609456506695829959148883148310p -0.3
+ 16761669978220659388294420609456506695829959148883148800p -0.3
+ 16761669978220659388294420609456506695829959148883148810p 0.9
+ 33523339956441318776588841218913013391659918297766297100p 0.9
+ 33523339956441318776588841218913013391659918297766297110p -0.3
+ 33523339956441318776588841218913013391659918297766297600p -0.3
+ 33523339956441318776588841218913013391659918297766297610p 0.9
+ 67046679912882637553177682437826026783319836595532594700p 0.9
+ 67046679912882637553177682437826026783319836595532594710p -0.3
+ 67046679912882637553177682437826026783319836595532595200p -0.3
+ 67046679912882637553177682437826026783319836595532595210p 0.9
+ 134093359825765275106355364875652053566639673191065189900p 0.9
+ 134093359825765275106355364875652053566639673191065189910p -0.3
+ 134093359825765275106355364875652053566639673191065190400p -0.3
+ 134093359825765275106355364875652053566639673191065190410p 0.9
+ 268186719651530550212710729751304107133279346382130380300p 0.9
+ 268186719651530550212710729751304107133279346382130380310p -0.3
+ 268186719651530550212710729751304107133279346382130380800p -0.3
+ 268186719651530550212710729751304107133279346382130380810p 0.9
+ 536373439303061100425421459502608214266558692764260761100p 0.9
+ 536373439303061100425421459502608214266558692764260761110p -0.3
+ 536373439303061100425421459502608214266558692764260761600p -0.3
+ 536373439303061100425421459502608214266558692764260761610p 0.9
+ 1072746878606122200850842919005216428533117385528521522700p 0.9
+ 1072746878606122200850842919005216428533117385528521522710p -0.3
+ 1072746878606122200850842919005216428533117385528521523200p -0.3
+ 1072746878606122200850842919005216428533117385528521523210p 0.9
+ 2145493757212244401701685838010432857066234771057043045900p 0.9
+ 2145493757212244401701685838010432857066234771057043045910p -0.3
+ 2145493757212244401701685838010432857066234771057043046400p -0.3
+ 2145493757212244401701685838010432857066234771057043046410p 0.9
+ 4290987514424488803403371676020865714132469542114086092300p 0.9
+ 4290987514424488803403371676020865714132469542114086092310p -0.3
+ 4290987514424488803403371676020865714132469542114086092800p -0.3
+ 4290987514424488803403371676020865714132469542114086092810p 0.9
+ 8581975028848977606806743352041731428264939084228172185100p 0.9
+ 8581975028848977606806743352041731428264939084228172185110p -0.3
+ 8581975028848977606806743352041731428264939084228172185600p -0.3
+ 8581975028848977606806743352041731428264939084228172185610p 0.9
+ 17163950057697955213613486704083462856529878168456344370700p 0.9
+ 17163950057697955213613486704083462856529878168456344370710p -0.3
+ 17163950057697955213613486704083462856529878168456344371200p -0.3
+ 17163950057697955213613486704083462856529878168456344371210p 0.9
+ 34327900115395910427226973408166925713059756336912688741900p 0.9
+ 34327900115395910427226973408166925713059756336912688741910p -0.3
+ 34327900115395910427226973408166925713059756336912688742400p -0.3
+ 34327900115395910427226973408166925713059756336912688742410p 0.9
+ 68655800230791820854453946816333851426119512673825377484300p 0.9
+ 68655800230791820854453946816333851426119512673825377484310p -0.3
+ 68655800230791820854453946816333851426119512673825377484800p -0.3
+ 68655800230791820854453946816333851426119512673825377484810p 0.9
+ 137311600461583641708907893632667702852239025347650754969100p 0.9
+ 137311600461583641708907893632667702852239025347650754969110p -0.3
+ 137311600461583641708907893632667702852239025347650754969600p -0.3
+ 137311600461583641708907893632667702852239025347650754969610p 0.9
+ 274623200923167283417815787265335405704478050695301509938700p 0.9
+ 274623200923167283417815787265335405704478050695301509938710p -0.3
+ 274623200923167283417815787265335405704478050695301509939200p -0.3
+ 274623200923167283417815787265335405704478050695301509939210p 0.9
+ 549246401846334566835631574530670811408956101390603019877900p 0.9
+ 549246401846334566835631574530670811408956101390603019877910p -0.3
+ 549246401846334566835631574530670811408956101390603019878400p -0.3
+ 549246401846334566835631574530670811408956101390603019878410p 0.9
+ 1098492803692669133671263149061341622817912202781206039756300p 0.9
+ 1098492803692669133671263149061341622817912202781206039756310p -0.3
+ 1098492803692669133671263149061341622817912202781206039756800p -0.3
+ 1098492803692669133671263149061341622817912202781206039756810p 0.9
+ 2196985607385338267342526298122683245635824405562412079513100p 0.9
+ 2196985607385338267342526298122683245635824405562412079513110p -0.3
+ 2196985607385338267342526298122683245635824405562412079513600p -0.3
+ 2196985607385338267342526298122683245635824405562412079513610p 0.9
+ 4393971214770676534685052596245366491271648811124824159026700p 0.9
+ 4393971214770676534685052596245366491271648811124824159026710p -0.3
+ 4393971214770676534685052596245366491271648811124824159027200p -0.3
+ 4393971214770676534685052596245366491271648811124824159027210p 0.9
+ 8787942429541353069370105192490732982543297622249648318053900p 0.9
+ 8787942429541353069370105192490732982543297622249648318053910p -0.3
+ 8787942429541353069370105192490732982543297622249648318054400p -0.3
+ 8787942429541353069370105192490732982543297622249648318054410p 0.9
+ 17575884859082706138740210384981465965086595244499296636108300p 0.9
+ 17575884859082706138740210384981465965086595244499296636108310p -0.3
+ 17575884859082706138740210384981465965086595244499296636108800p -0.3
+ 17575884859082706138740210384981465965086595244499296636108810p 0.9
+ 35151769718165412277480420769962931930173190488998593272217100p 0.9
+ 35151769718165412277480420769962931930173190488998593272217110p -0.3
+ 35151769718165412277480420769962931930173190488998593272217600p -0.3
+ 35151769718165412277480420769962931930173190488998593272217610p 0.9
+ 70303539436330824554960841539925863860346380977997186544434700p 0.9
+ 70303539436330824554960841539925863860346380977997186544434710p -0.3
+ 70303539436330824554960841539925863860346380977997186544435200p -0.3
+ 70303539436330824554960841539925863860346380977997186544435210p 0.9
+ 140607078872661649109921683079851727720692761955994373088869900p 0.9
+ 140607078872661649109921683079851727720692761955994373088869910p -0.3
+ 140607078872661649109921683079851727720692761955994373088870400p -0.3
+ 140607078872661649109921683079851727720692761955994373088870410p 0.9
+ 281214157745323298219843366159703455441385523911988746177740300p 0.9
+ 281214157745323298219843366159703455441385523911988746177740310p -0.3
+ 281214157745323298219843366159703455441385523911988746177740800p -0.3
+ 281214157745323298219843366159703455441385523911988746177740810p 0.9
+ 562428315490646596439686732319406910882771047823977492355481100p 0.9
+ 562428315490646596439686732319406910882771047823977492355481110p -0.3
+ 562428315490646596439686732319406910882771047823977492355481600p -0.3
+ 562428315490646596439686732319406910882771047823977492355481610p 0.9
+ 1124856630981293192879373464638813821765542095647954984710962700p 0.9
+ 1124856630981293192879373464638813821765542095647954984710962710p -0.3
+ 1124856630981293192879373464638813821765542095647954984710963200p -0.3
+ 1124856630981293192879373464638813821765542095647954984710963210p 0.9
+ 2249713261962586385758746929277627643531084191295909969421925900p 0.9
+ 2249713261962586385758746929277627643531084191295909969421925910p -0.3
+ 2249713261962586385758746929277627643531084191295909969421926400p -0.3
+ 2249713261962586385758746929277627643531084191295909969421926410p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852300p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852310p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852800p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852810p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705100p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705110p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705600p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705610p 0.9
+ 17997706095700691086069975434221021148248673530367279755375410700p 0.9
+ 17997706095700691086069975434221021148248673530367279755375410710p -0.3
+ 17997706095700691086069975434221021148248673530367279755375411200p -0.3
+ 17997706095700691086069975434221021148248673530367279755375411210p 0.9
+ 35995412191401382172139950868442042296497347060734559510750821900p 0.9
+ 35995412191401382172139950868442042296497347060734559510750821910p -0.3
+ 35995412191401382172139950868442042296497347060734559510750822400p -0.3
+ 35995412191401382172139950868442042296497347060734559510750822410p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644300p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644310p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644800p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644810p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289100p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289110p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289600p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289610p 0.9
+ 287963297531211057377119606947536338371978776485876476086006578700p 0.9
+ 287963297531211057377119606947536338371978776485876476086006578710p -0.3
+ 287963297531211057377119606947536338371978776485876476086006579200p -0.3
+ 287963297531211057377119606947536338371978776485876476086006579210p 0.9
+ 575926595062422114754239213895072676743957552971752952172013157900p 0.9
+ 575926595062422114754239213895072676743957552971752952172013157910p -0.3
+ 575926595062422114754239213895072676743957552971752952172013158400p -0.3
+ 575926595062422114754239213895072676743957552971752952172013158410p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316300p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316310p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316800p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316810p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633100p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633110p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633600p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633610p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105266700p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105266710p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105267200p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105267210p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210533900p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210533910p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210534400p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210534410p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068300p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068310p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068800p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068810p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137100p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137110p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137600p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137610p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684274700p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684274710p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684275200p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684275210p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368549900p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368549910p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368550400p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368550410p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100300p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100310p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100800p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100810p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201100p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201110p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201600p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201610p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948402700p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948402710p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948403200p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948403210p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896805900p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896805910p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896806400p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896806410p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612300p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612310p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612800p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612810p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225100p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225110p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225600p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225610p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174450700p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174450710p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174451200p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174451210p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348901900p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348901910p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348902400p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348902410p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804300p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804310p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804800p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804810p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609100p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609110p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609600p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609610p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791218700p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791218710p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791219200p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791219210p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582437900p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582437910p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582438400p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582438410p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876300p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876310p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876800p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876810p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753100p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753110p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753600p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753610p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659506700p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659506710p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659507200p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659507210p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319013900p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319013910p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319014400p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319014410p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028300p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028310p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028800p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028810p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057100p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057110p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057600p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057610p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552114700p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552114710p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552115200p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552115210p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104229900p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104229910p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104230400p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104230410p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460300p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460310p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460800p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460810p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921100p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921110p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921600p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921610p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833842700p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833842710p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833843200p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833843210p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667685900p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667685910p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667686400p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667686410p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372300p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372310p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372800p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372810p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745100p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745110p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745600p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745610p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341490700p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341490710p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341491200p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341491210p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682981900p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682981910p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682982400p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682982410p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964300p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964310p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964800p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964810p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929100p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929110p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929600p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929610p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463858700p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463858710p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463859200p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463859210p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927717900p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927717910p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927718400p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927718410p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436300p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436310p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436800p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436810p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873100p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873110p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873600p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873610p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746700p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746710p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747200p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747210p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493900p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493910p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494400p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494410p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988300p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988310p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988800p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988810p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977100p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977110p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977600p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977610p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954700p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954710p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955200p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955210p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909900p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909910p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910400p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910410p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820300p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820310p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820800p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820810p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641100p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641110p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641600p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641610p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282700p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282710p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283200p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283210p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565900p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565910p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566400p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566410p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132300p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132310p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132800p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132810p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265100p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265110p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265600p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265610p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530700p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530710p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531200p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531210p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061900p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061910p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062400p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062410p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124300p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124310p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124800p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124810p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249100p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249110p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249600p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249610p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498700p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498710p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499200p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499210p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997900p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997910p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998400p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998410p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996300p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996310p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996800p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996810p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993100p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993110p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993600p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993610p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986700p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986710p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987200p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987210p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973900p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973910p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974400p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974410p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948300p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948310p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948800p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948810p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897100p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897110p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897600p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897610p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794700p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794710p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795200p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795210p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589900p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589910p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590400p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590410p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180300p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180310p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180800p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180810p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361100p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361110p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361600p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361610p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722700p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722710p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723200p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723210p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445900p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445910p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446400p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446410p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892300p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892310p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892800p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892810p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785100p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785110p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785600p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785610p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570700p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570710p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571200p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571210p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141900p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141910p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142400p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142410p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284300p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284310p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284800p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284810p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569100p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569110p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569600p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569610p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138700p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138710p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139200p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139210p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277900p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277910p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278400p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278410p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556300p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556310p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556800p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556810p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113100p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113110p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113600p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113610p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226700p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226710p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227200p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227210p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453900p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453910p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454400p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454410p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908300p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908310p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908800p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908810p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817100p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817110p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817600p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817610p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634700p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634710p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635200p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635210p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269900p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269910p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270400p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270410p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540300p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540310p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540800p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540810p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081100p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081110p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081600p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081610p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162700p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162710p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163200p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163210p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325900p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325910p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326400p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326410p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652300p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652310p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652800p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652810p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305100p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305110p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305600p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305610p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610700p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610710p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611200p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611210p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221900p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221910p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222400p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222410p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444300p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444310p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444800p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444810p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889100p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889110p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889600p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889610p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778700p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778710p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779200p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779210p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557900p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557910p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558400p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558410p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116300p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116310p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116800p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116810p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233100p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233110p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233600p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233610p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466700p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466710p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467200p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467210p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933900p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933910p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934400p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934410p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868300p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868310p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868800p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868810p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737100p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737110p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737600p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737610p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474700p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474710p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475200p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475210p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949900p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949910p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950400p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950410p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900300p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900310p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900800p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900810p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801100p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801110p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801600p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801610p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602700p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602710p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603200p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603210p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205900p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205910p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206400p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206410p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412300p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412310p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412800p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412810p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825100p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825110p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825600p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825610p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650700p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650710p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651200p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651210p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301900p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301910p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302400p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302410p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604300p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604310p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604800p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604810p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209100p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209110p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209600p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209610p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418700p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418710p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419200p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419210p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837900p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837910p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838400p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838410p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676300p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676310p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676800p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676810p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353100p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353110p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353600p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353610p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706700p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706710p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707200p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707210p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413900p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413910p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414400p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414410p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828300p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828310p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828800p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828810p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657100p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657110p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657600p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657610p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314700p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314710p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315200p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315210p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629900p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629910p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630400p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630410p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260300p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260310p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260800p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260810p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521100p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521110p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521600p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521610p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042700p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042710p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043200p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043210p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085900p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085910p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086400p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086410p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172300p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172310p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172800p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172810p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345100p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345110p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345600p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345610p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690700p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690710p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691200p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691210p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381900p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381910p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382400p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382410p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764300p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764310p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764800p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764810p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529100p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529110p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529600p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529610p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058700p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058710p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059200p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059210p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117900p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117910p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118400p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118410p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236300p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236310p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236800p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236810p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473100p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473110p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473600p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473610p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946700p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946710p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947200p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947210p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893900p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893910p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894400p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894410p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788300p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788310p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788800p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788810p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577100p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577110p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577600p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577610p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154700p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154710p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155200p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155210p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309900p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309910p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310400p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310410p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620300p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620310p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620800p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620810p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241100p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241110p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241600p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241610p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482700p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482710p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483200p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483210p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965900p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965910p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966400p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966410p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932300p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932310p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932800p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932810p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865100p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865110p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865600p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865610p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730700p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730710p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731200p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731210p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461900p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461910p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462400p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462410p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924300p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924310p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924800p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924810p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849100p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849110p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849600p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849610p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698700p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698710p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699200p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699210p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397900p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397910p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398400p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398410p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796300p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796310p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796800p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796810p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593100p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593110p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593600p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593610p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186700p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186710p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187200p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187210p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373900p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373910p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374400p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374410p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748300p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748310p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748800p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748810p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497100p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497110p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497600p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497610p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994700p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994710p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995200p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995210p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989900p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989910p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990400p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990410p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980300p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980310p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980800p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980810p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961100p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961110p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961600p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961610p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922700p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922710p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923200p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923210p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845900p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845910p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846400p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846410p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692300p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692310p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692800p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692810p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385100p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385110p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385600p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385610p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770700p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770710p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771200p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771210p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541900p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541910p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542400p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542410p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084300p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084310p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084800p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084810p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169100p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169110p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169600p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169610p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338700p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338710p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339200p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339210p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677900p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677910p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678400p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678410p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356300p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356310p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356800p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356810p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713100p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713110p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713600p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713610p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426700p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426710p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427200p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427210p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853900p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853910p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854400p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854410p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708300p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708310p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708800p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708810p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417100p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417110p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417600p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417610p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834700p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834710p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835200p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835210p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669900p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669910p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670400p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670410p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340300p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340310p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340800p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340810p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681100p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681110p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681600p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681610p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362700p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362710p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363200p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363210p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725900p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725910p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726400p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726410p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452300p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452310p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452800p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452810p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905100p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905110p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905600p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905610p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810700p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810710p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811200p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811210p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621900p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621910p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622400p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622410p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244300p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244310p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244800p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244810p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489100p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489110p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489600p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489610p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978700p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978710p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979200p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979210p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957900p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957910p -0.3
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958400p -0.3
