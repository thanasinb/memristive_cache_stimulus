+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713600p -0.3
+ 11556442868592677263957432795048800767599785257040158296549140509958491618428356301002877472542500985196002390477499689850551352864121246127355540153876803244870958712478236216191001949171828398034905094867119746340738118903940413037089932160528922923208656457138018713610p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426700p 0.9
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037426710p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427200p -0.3
+ 23112885737185354527914865590097601535199570514080316593098281019916983236856712602005754945085001970392004780954999379701102705728242492254711080307753606489741917424956472432382003898343656796069810189734239492681476237807880826074179864321057845846417312914276037427210p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853900p 0.9
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074853910p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854400p -0.3
+ 46225771474370709055829731180195203070399141028160633186196562039833966473713425204011509890170003940784009561909998759402205411456484984509422160615507212979483834849912944864764007796687313592139620379468478985362952475615761652148359728642115691692834625828552074854410p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708300p 0.9
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708310p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708800p -0.3
+ 92451542948741418111659462360390406140798282056321266372393124079667932947426850408023019780340007881568019123819997518804410822912969969018844321231014425958967669699825889729528015593374627184279240758936957970725904951231523304296719457284231383385669251657104149708810p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417100p 0.9
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417110p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417600p -0.3
+ 184903085897482836223318924720780812281596564112642532744786248159335865894853700816046039560680015763136038247639995037608821645825939938037688642462028851917935339399651779459056031186749254368558481517873915941451809902463046608593438914568462766771338503314208299417610p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834700p 0.9
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598834710p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835200p -0.3
+ 369806171794965672446637849441561624563193128225285065489572496318671731789707401632092079121360031526272076495279990075217643291651879876075377284924057703835870678799303558918112062373498508737116963035747831882903619804926093217186877829136925533542677006628416598835210p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669900p 0.9
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197669910p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670400p -0.3
+ 739612343589931344893275698883123249126386256450570130979144992637343463579414803264184158242720063052544152990559980150435286583303759752150754569848115407671741357598607117836224124746997017474233926071495663765807239609852186434373755658273851067085354013256833197670410p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340300p 0.9
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340310p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340800p -0.3
+ 1479224687179862689786551397766246498252772512901140261958289985274686927158829606528368316485440126105088305981119960300870573166607519504301509139696230815343482715197214235672448249493994034948467852142991327531614479219704372868747511316547702134170708026513666395340810p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681100p 0.9
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681110p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681600p -0.3
+ 2958449374359725379573102795532492996505545025802280523916579970549373854317659213056736632970880252210176611962239920601741146333215039008603018279392461630686965430394428471344896498987988069896935704285982655063228958439408745737495022633095404268341416053027332790681610p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362700p 0.9
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581362710p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363200p -0.3
+ 5916898748719450759146205591064985993011090051604561047833159941098747708635318426113473265941760504420353223924479841203482292666430078017206036558784923261373930860788856942689792997975976139793871408571965310126457916878817491474990045266190808536682832106054665581363210p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725900p 0.9
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162725910p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726400p -0.3
+ 11833797497438901518292411182129971986022180103209122095666319882197495417270636852226946531883521008840706447848959682406964585332860156034412073117569846522747861721577713885379585995951952279587742817143930620252915833757634982949980090532381617073365664212109331162726410p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452300p 0.9
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452310p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452800p -0.3
+ 23667594994877803036584822364259943972044360206418244191332639764394990834541273704453893063767042017681412895697919364813929170665720312068824146235139693045495723443155427770759171991903904559175485634287861240505831667515269965899960181064763234146731328424218662325452810p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905100p 0.9
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905110p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905600p -0.3
+ 47335189989755606073169644728519887944088720412836488382665279528789981669082547408907786127534084035362825791395838729627858341331440624137648292470279386090991446886310855541518343983807809118350971268575722481011663335030539931799920362129526468293462656848437324650905610p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810700p 0.9
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301810710p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811200p -0.3
+ 94670379979511212146339289457039775888177440825672976765330559057579963338165094817815572255068168070725651582791677459255716682662881248275296584940558772181982893772621711083036687967615618236701942537151444962023326670061079863599840724259052936586925313696874649301811210p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621900p 0.9
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603621910p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622400p -0.3
+ 189340759959022424292678578914079551776354881651345953530661118115159926676330189635631144510136336141451303165583354918511433365325762496550593169881117544363965787545243422166073375935231236473403885074302889924046653340122159727199681448518105873173850627393749298603622410p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244300p 0.9
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244310p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244800p -0.3
+ 378681519918044848585357157828159103552709763302691907061322236230319853352660379271262289020272672282902606331166709837022866730651524993101186339762235088727931575090486844332146751870462472946807770148605779848093306680244319454399362897036211746347701254787498597207244810p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489100p 0.9
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489110p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489600p -0.3
+ 757363039836089697170714315656318207105419526605383814122644472460639706705320758542524578040545344565805212662333419674045733461303049986202372679524470177455863150180973688664293503740924945893615540297211559696186613360488638908798725794072423492695402509574997194414489610p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978700p 0.9
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828978710p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979200p -0.3
+ 1514726079672179394341428631312636414210839053210767628245288944921279413410641517085049156081090689131610425324666839348091466922606099972404745359048940354911726300361947377328587007481849891787231080594423119392373226720977277817597451588144846985390805019149994388828979210p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957900p 0.9
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657957910p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958400p -0.3
+ 3029452159344358788682857262625272828421678106421535256490577889842558826821283034170098312162181378263220850649333678696182933845212199944809490718097880709823452600723894754657174014963699783574462161188846238784746453441954555635194903176289693970781610038299988777657958410p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916300p 0.9
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916310p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916800p -0.3
+ 6058904318688717577365714525250545656843356212843070512981155779685117653642566068340196624324362756526441701298667357392365867690424399889618981436195761419646905201447789509314348029927399567148924322377692477569492906883909111270389806352579387941563220076599977555315916810p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833100p 0.9
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833110p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833600p -0.3
+ 12117808637377435154731429050501091313686712425686141025962311559370235307285132136680393248648725513052883402597334714784731735380848799779237962872391522839293810402895579018628696059854799134297848644755384955138985813767818222540779612705158775883126440153199955110631833610p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666700p 0.9
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263666710p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667200p -0.3
+ 24235617274754870309462858101002182627373424851372282051924623118740470614570264273360786497297451026105766805194669429569463470761697599558475925744783045678587620805791158037257392119709598268595697289510769910277971627535636445081559225410317551766252880306399910221263667210p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333900p 0.9
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527333910p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334400p -0.3
+ 48471234549509740618925716202004365254746849702744564103849246237480941229140528546721572994594902052211533610389338859138926941523395199116951851489566091357175241611582316074514784239419196537191394579021539820555943255071272890163118450820635103532505760612799820442527334410p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668300p 0.9
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668310p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668800p -0.3
+ 96942469099019481237851432404008730509493699405489128207698492474961882458281057093443145989189804104423067220778677718277853883046790398233903702979132182714350483223164632149029568478838393074382789158043079641111886510142545780326236901641270207065011521225599640885054668810p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337100p 0.9
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337110p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337600p -0.3
+ 193884938198038962475702864808017461018987398810978256415396984949923764916562114186886291978379608208846134441557355436555707766093580796467807405958264365428700966446329264298059136957676786148765578316086159282223773020285091560652473803282540414130023042451199281770109337610p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674700p 0.9
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218674710p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675200p -0.3
+ 387769876396077924951405729616034922037974797621956512830793969899847529833124228373772583956759216417692268883114710873111415532187161592935614811916528730857401932892658528596118273915353572297531156632172318564447546040570183121304947606565080828260046084902398563540218675210p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349900p 0.9
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437349910p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350400p -0.3
+ 775539752792155849902811459232069844075949595243913025661587939799695059666248456747545167913518432835384537766229421746222831064374323185871229623833057461714803865785317057192236547830707144595062313264344637128895092081140366242609895213130161656520092169804797127080437350410p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700300p 0.9
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700310p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700800p -0.3
+ 1551079505584311699805622918464139688151899190487826051323175879599390119332496913495090335827036865670769075532458843492445662128748646371742459247666114923429607731570634114384473095661414289190124626528689274257790184162280732485219790426260323313040184339609594254160874700810p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401100p 0.9
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401110p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401600p -0.3
+ 3102159011168623399611245836928279376303798380975652102646351759198780238664993826990180671654073731341538151064917686984891324257497292743484918495332229846859215463141268228768946191322828578380249253057378548515580368324561464970439580852520646626080368679219188508321749401610p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802700p 0.9
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498802710p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803200p -0.3
+ 6204318022337246799222491673856558752607596761951304205292703518397560477329987653980361343308147462683076302129835373969782648514994585486969836990664459693718430926282536457537892382645657156760498506114757097031160736649122929940879161705041293252160737358438377016643498803210p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605900p 0.9
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997605910p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606400p -0.3
+ 12408636044674493598444983347713117505215193523902608410585407036795120954659975307960722686616294925366152604259670747939565297029989170973939673981328919387436861852565072915075784765291314313520997012229514194062321473298245859881758323410082586504321474716876754033286997606410p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212300p 0.9
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212310p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212800p -0.3
+ 24817272089348987196889966695426235010430387047805216821170814073590241909319950615921445373232589850732305208519341495879130594059978341947879347962657838774873723705130145830151569530582628627041994024459028388124642946596491719763516646820165173008642949433753508066573995212810p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425100p 0.9
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425110p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425600p -0.3
+ 49634544178697974393779933390852470020860774095610433642341628147180483818639901231842890746465179701464610417038682991758261188119956683895758695925315677549747447410260291660303139061165257254083988048918056776249285893192983439527033293640330346017285898867507016133147990425610p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850700p 0.9
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980850710p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851200p -0.3
+ 99269088357395948787559866781704940041721548191220867284683256294360967637279802463685781492930359402929220834077365983516522376239913367791517391850631355099494894820520583320606278122330514508167976097836113552498571786385966879054066587280660692034571797735014032266295980851210p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701900p 0.9
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961701910p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702400p -0.3
+ 198538176714791897575119733563409880083443096382441734569366512588721935274559604927371562985860718805858441668154731967033044752479826735583034783701262710198989789641041166641212556244661029016335952195672227104997143572771933758108133174561321384069143595470028064532591961702410p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404300p 0.9
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404310p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404800p -0.3
+ 397076353429583795150239467126819760166886192764883469138733025177443870549119209854743125971721437611716883336309463934066089504959653471166069567402525420397979579282082333282425112489322058032671904391344454209994287145543867516216266349122642768138287190940056129065183923404810p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809100p 0.9
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809110p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809600p -0.3
+ 794152706859167590300478934253639520333772385529766938277466050354887741098238419709486251943442875223433766672618927868132179009919306942332139134805050840795959158564164666564850224978644116065343808782688908419988574291087735032432532698245285536276574381880112258130367846809610p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618700p 0.9
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693618710p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619200p -0.3
+ 1588305413718335180600957868507279040667544771059533876554932100709775482196476839418972503886885750446867533345237855736264358019838613884664278269610101681591918317128329333129700449957288232130687617565377816839977148582175470064865065396490571072553148763760224516260735693619210p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237900p 0.9
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387237910p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238400p -0.3
+ 3176610827436670361201915737014558081335089542119067753109864201419550964392953678837945007773771500893735066690475711472528716039677227769328556539220203363183836634256658666259400899914576464261375235130755633679954297164350940129730130792981142145106297527520449032521471387238410p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476300p 0.9
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476310p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476800p -0.3
+ 6353221654873340722403831474029116162670179084238135506219728402839101928785907357675890015547543001787470133380951422945057432079354455538657113078440406726367673268513317332518801799829152928522750470261511267359908594328701880259460261585962284290212595055040898065042942774476810p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953100p 0.9
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953110p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953600p -0.3
+ 12706443309746681444807662948058232325340358168476271012439456805678203857571814715351780031095086003574940266761902845890114864158708911077314226156880813452735346537026634665037603599658305857045500940523022534719817188657403760518920523171924568580425190110081796130085885548953610p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906700p 0.9
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097906710p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907200p -0.3
+ 25412886619493362889615325896116464650680716336952542024878913611356407715143629430703560062190172007149880533523805691780229728317417822154628452313761626905470693074053269330075207199316611714091001881046045069439634377314807521037841046343849137160850380220163592260171771097907210p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813900p 0.9
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195813910p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814400p -0.3
+ 50825773238986725779230651792232929301361432673905084049757827222712815430287258861407120124380344014299761067047611383560459456634835644309256904627523253810941386148106538660150414398633223428182003762092090138879268754629615042075682092687698274321700760440327184520343542195814410p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628300p 0.9
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628310p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628800p -0.3
+ 101651546477973451558461303584465858602722865347810168099515654445425630860574517722814240248760688028599522134095222767120918913269671288618513809255046507621882772296213077320300828797266446856364007524184180277758537509259230084151364185375396548643401520880654369040687084391628810p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257100p 0.9
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257110p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257600p -0.3
+ 203303092955946903116922607168931717205445730695620336199031308890851261721149035445628480497521376057199044268190445534241837826539342577237027618510093015243765544592426154640601657594532893712728015048368360555517075018518460168302728370750793097286803041761308738081374168783257610p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514700p 0.9
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566514710p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515200p -0.3
+ 406606185911893806233845214337863434410891461391240672398062617781702523442298070891256960995042752114398088536380891068483675653078685154474055237020186030487531089184852309281203315189065787425456030096736721111034150037036920336605456741501586194573606083522617476162748337566515210p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029900p 0.9
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133029910p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030400p -0.3
+ 813212371823787612467690428675726868821782922782481344796125235563405046884596141782513921990085504228796177072761782136967351306157370308948110474040372060975062178369704618562406630378131574850912060193473442222068300074073840673210913483003172389147212167045234952325496675133030410p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060300p 0.9
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060310p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060800p -0.3
+ 1626424743647575224935380857351453737643565845564962689592250471126810093769192283565027843980171008457592354145523564273934702612314740617896220948080744121950124356739409237124813260756263149701824120386946884444136600148147681346421826966006344778294424334090469904650993350266060810p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121100p 0.9
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121110p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121600p -0.3
+ 3252849487295150449870761714702907475287131691129925379184500942253620187538384567130055687960342016915184708291047128547869405224629481235792441896161488243900248713478818474249626521512526299403648240773893768888273200296295362692843653932012689556588848668180939809301986700532121610p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242700p 0.9
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064242710p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243200p -0.3
+ 6505698974590300899741523429405814950574263382259850758369001884507240375076769134260111375920684033830369416582094257095738810449258962471584883792322976487800497426957636948499253043025052598807296481547787537776546400592590725385687307864025379113177697336361879618603973401064243210p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485900p 0.9
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128485910p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486400p -0.3
+ 13011397949180601799483046858811629901148526764519701516738003769014480750153538268520222751841368067660738833164188514191477620898517924943169767584645952975600994853915273896998506086050105197614592963095575075553092801185181450771374615728050758226355394672723759237207946802128486410p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972300p 0.9
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972310p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972800p -0.3
+ 26022795898361203598966093717623259802297053529039403033476007538028961500307076537040445503682736135321477666328377028382955241797035849886339535169291905951201989707830547793997012172100210395229185926191150151106185602370362901542749231456101516452710789345447518474415893604256972810p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945100p 0.9
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945110p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945600p -0.3
+ 52045591796722407197932187435246519604594107058078806066952015076057923000614153074080891007365472270642955332656754056765910483594071699772679070338583811902403979415661095587994024344200420790458371852382300302212371204740725803085498462912203032905421578690895036948831787208513945610p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890700p 0.9
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027890710p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891200p -0.3
+ 104091183593444814395864374870493039209188214116157612133904030152115846001228306148161782014730944541285910665313508113531820967188143399545358140677167623804807958831322191175988048688400841580916743704764600604424742409481451606170996925824406065810843157381790073897663574417027891210p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781900p 0.9
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055781910p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782400p -0.3
+ 208182367186889628791728749740986078418376428232315224267808060304231692002456612296323564029461889082571821330627016227063641934376286799090716281354335247609615917662644382351976097376801683161833487409529201208849484818962903212341993851648812131621686314763580147795327148834055782410p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564300p 0.9
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564310p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564800p -0.3
+ 416364734373779257583457499481972156836752856464630448535616120608463384004913224592647128058923778165143642661254032454127283868752573598181432562708670495219231835325288764703952194753603366323666974819058402417698969637925806424683987703297624263243372629527160295590654297668111564810p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129100p 0.9
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129110p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129600p -0.3
+ 832729468747558515166914998963944313673505712929260897071232241216926768009826449185294256117847556330287285322508064908254567737505147196362865125417340990438463670650577529407904389507206732647333949638116804835397939275851612849367975406595248526486745259054320591181308595336223129610p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258700p 0.9
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446258710p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259200p -0.3
+ 1665458937495117030333829997927888627347011425858521794142464482433853536019652898370588512235695112660574570645016129816509135475010294392725730250834681980876927341301155058815808779014413465294667899276233609670795878551703225698735950813190497052973490518108641182362617190672446259210p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517900p 0.9
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892517910p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518400p -0.3
+ 3330917874990234060667659995855777254694022851717043588284928964867707072039305796741177024471390225321149141290032259633018270950020588785451460501669363961753854682602310117631617558028826930589335798552467219341591757103406451397471901626380994105946981036217282364725234381344892518410p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036300p 0.9
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036310p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036800p -0.3
+ 6661835749980468121335319991711554509388045703434087176569857929735414144078611593482354048942780450642298282580064519266036541900041177570902921003338727923507709365204620235263235116057653861178671597104934438683183514206812902794943803252761988211893962072434564729450468762689785036810p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073100p 0.9
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073110p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073600p -0.3
+ 13323671499960936242670639983423109018776091406868174353139715859470828288157223186964708097885560901284596565160129038532073083800082355141805842006677455847015418730409240470526470232115307722357343194209868877366367028413625805589887606505523976423787924144869129458900937525379570073610p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146700p 0.9
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140146710p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147200p -0.3
+ 26647342999921872485341279966846218037552182813736348706279431718941656576314446373929416195771121802569193130320258077064146167600164710283611684013354911694030837460818480941052940464230615444714686388419737754732734056827251611179775213011047952847575848289738258917801875050759140147210p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293900p 0.9
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280293910p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294400p -0.3
+ 53294685999843744970682559933692436075104365627472697412558863437883313152628892747858832391542243605138386260640516154128292335200329420567223368026709823388061674921636961882105880928461230889429372776839475509465468113654503222359550426022095905695151696579476517835603750101518280294410p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588300p 0.9
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588310p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588800p -0.3
+ 106589371999687489941365119867384872150208731254945394825117726875766626305257785495717664783084487210276772521281032308256584670400658841134446736053419646776123349843273923764211761856922461778858745553678951018930936227309006444719100852044191811390303393158953035671207500203036560588810p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177100p 0.9
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177110p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177600p -0.3
+ 213178743999374979882730239734769744300417462509890789650235453751533252610515570991435329566168974420553545042562064616513169340801317682268893472106839293552246699686547847528423523713844923557717491107357902037861872454618012889438201704088383622780606786317906071342415000406073121177610p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354700p 0.9
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242354710p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355200p -0.3
+ 426357487998749959765460479469539488600834925019781579300470907503066505221031141982870659132337948841107090085124129233026338681602635364537786944213678587104493399373095695056847047427689847115434982214715804075723744909236025778876403408176767245561213572635812142684830000812146242355210p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709900p 0.9
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484709910p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710400p -0.3
+ 852714975997499919530920958939078977201669850039563158600941815006133010442062283965741318264675897682214180170248258466052677363205270729075573888427357174208986798746191390113694094855379694230869964429431608151447489818472051557752806816353534491122427145271624285369660001624292484710410p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420300p 0.9
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420310p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420800p -0.3
+ 1705429951994999839061841917878157954403339700079126317201883630012266020884124567931482636529351795364428360340496516932105354726410541458151147776854714348417973597492382780227388189710759388461739928858863216302894979636944103115505613632707068982244854290543248570739320003248584969420810p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841100p 0.9
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841110p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841600p -0.3
+ 3410859903989999678123683835756315908806679400158252634403767260024532041768249135862965273058703590728856720680993033864210709452821082916302295553709428696835947194984765560454776379421518776923479857717726432605789959273888206231011227265414137964489708581086497141478640006497169938841610p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682700p 0.9
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877682710p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683200p -0.3
+ 6821719807979999356247367671512631817613358800316505268807534520049064083536498271725930546117407181457713441361986067728421418905642165832604591107418857393671894389969531120909552758843037553846959715435452865211579918547776412462022454530828275928979417162172994282957280012994339877683210p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365900p 0.9
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755365910p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366400p -0.3
+ 13643439615959998712494735343025263635226717600633010537615069040098128167072996543451861092234814362915426882723972135456842837811284331665209182214837714787343788779939062241819105517686075107693919430870905730423159837095552824924044909061656551857958834324345988565914560025988679755366410p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732300p 0.9
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732310p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732800p -0.3
+ 27286879231919997424989470686050527270453435201266021075230138080196256334145993086903722184469628725830853765447944270913685675622568663330418364429675429574687577559878124483638211035372150215387838861741811460846319674191105649848089818123313103715917668648691977131829120051977359510732810p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465100p 0.9
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465110p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465600p -0.3
+ 54573758463839994849978941372101054540906870402532042150460276160392512668291986173807444368939257451661707530895888541827371351245137326660836728859350859149375155119756248967276422070744300430775677723483622921692639348382211299696179636246626207431835337297383954263658240103954719021465610p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930700p 0.9
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042930710p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931200p -0.3
+ 109147516927679989699957882744202109081813740805064084300920552320785025336583972347614888737878514903323415061791777083654742702490274653321673457718701718298750310239512497934552844141488600861551355446967245843385278696764422599392359272493252414863670674594767908527316480207909438042931210p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861900p 0.9
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085861910p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862400p -0.3
+ 218295033855359979399915765488404218163627481610128168601841104641570050673167944695229777475757029806646830123583554167309485404980549306643346915437403436597500620479024995869105688282977201723102710893934491686770557393528845198784718544986504829727341349189535817054632960415818876085862410p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724300p 0.9
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724310p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724800p -0.3
+ 436590067710719958799831530976808436327254963220256337203682209283140101346335889390459554951514059613293660247167108334618970809961098613286693830874806873195001240958049991738211376565954403446205421787868983373541114787057690397569437089973009659454682698379071634109265920831637752171724810p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449100p 0.9
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449110p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449600p -0.3
+ 873180135421439917599663061953616872654509926440512674407364418566280202692671778780919109903028119226587320494334216669237941619922197226573387661749613746390002481916099983476422753131908806892410843575737966747082229574115380795138874179946019318909365396758143268218531841663275504343449610p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898700p 0.9
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686898710p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899200p -0.3
+ 1746360270842879835199326123907233745309019852881025348814728837132560405385343557561838219806056238453174640988668433338475883239844394453146775323499227492780004963832199966952845506263817613784821687151475933494164459148230761590277748359892038637818730793516286536437063683326551008686899210p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797900p 0.9
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373797910p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798400p -0.3
+ 3492720541685759670398652247814467490618039705762050697629457674265120810770687115123676439612112476906349281977336866676951766479688788906293550646998454985560009927664399933905691012527635227569643374302951866988328918296461523180555496719784077275637461587032573072874127366653102017373798410p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596300p 0.9
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596310p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596800p -0.3
+ 6985441083371519340797304495628934981236079411524101395258915348530241621541374230247352879224224953812698563954673733353903532959377577812587101293996909971120019855328799867811382025055270455139286748605903733976657836592923046361110993439568154551274923174065146145748254733306204034747596810p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193100p 0.9
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193110p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193600p -0.3
+ 13970882166743038681594608991257869962472158823048202790517830697060483243082748460494705758448449907625397127909347466707807065918755155625174202587993819942240039710657599735622764050110540910278573497211807467953315673185846092722221986879136309102549846348130292291496509466612408069495193610p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386700p 0.9
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990386710p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387200p -0.3
+ 27941764333486077363189217982515739924944317646096405581035661394120966486165496920989411516896899815250794255818694933415614131837510311250348405175987639884480079421315199471245528100221081820557146994423614935906631346371692185444443973758272618205099692696260584582993018933224816138990387210p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773900p 0.9
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980773910p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774400p -0.3
+ 55883528666972154726378435965031479849888635292192811162071322788241932972330993841978823033793799630501588511637389866831228263675020622500696810351975279768960158842630398942491056200442163641114293988847229871813262692743384370888887947516545236410199385392521169165986037866449632277980774410p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548300p 0.9
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548310p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548800p -0.3
+ 111767057333944309452756871930062959699777270584385622324142645576483865944661987683957646067587599261003177023274779733662456527350041245001393620703950559537920317685260797884982112400884327282228587977694459743626525385486768741777775895033090472820398770785042338331972075732899264555961548810p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097100p 0.9
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097110p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097600p -0.3
+ 223534114667888618905513743860125919399554541168771244648285291152967731889323975367915292135175198522006354046549559467324913054700082490002787241407901119075840635370521595769964224801768654564457175955388919487253050770973537483555551790066180945640797541570084676663944151465798529111923097610p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194700p 0.9
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846194710p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195200p -0.3
+ 447068229335777237811027487720251838799109082337542489296570582305935463778647950735830584270350397044012708093099118934649826109400164980005574482815802238151681270741043191539928449603537309128914351910777838974506101541947074967111103580132361891281595083140169353327888302931597058223846195210p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389900p 0.9
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692389910p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390400p -0.3
+ 894136458671554475622054975440503677598218164675084978593141164611870927557295901471661168540700794088025416186198237869299652218800329960011148965631604476303362541482086383079856899207074618257828703821555677949012203083894149934222207160264723782563190166280338706655776605863194116447692390410p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780300p 0.9
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780310p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780800p -0.3
+ 1788272917343108951244109950881007355196436329350169957186282329223741855114591802943322337081401588176050832372396475738599304437600659920022297931263208952606725082964172766159713798414149236515657407643111355898024406167788299868444414320529447565126380332560677413311553211726388232895384780810p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561100p 0.9
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561110p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561600p -0.3
+ 3576545834686217902488219901762014710392872658700339914372564658447483710229183605886644674162803176352101664744792951477198608875201319840044595862526417905213450165928345532319427596828298473031314815286222711796048812335576599736888828641058895130252760665121354826623106423452776465790769561610p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122700p 0.9
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539122710p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123200p -0.3
+ 7153091669372435804976439803524029420785745317400679828745129316894967420458367211773289348325606352704203329489585902954397217750402639680089191725052835810426900331856691064638855193656596946062629630572445423592097624671153199473777657282117790260505521330242709653246212846905552931581539123210p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245900p 0.9
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078245910p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246400p -0.3
+ 14306183338744871609952879607048058841571490634801359657490258633789934840916734423546578696651212705408406658979171805908794435500805279360178383450105671620853800663713382129277710387313193892125259261144890847184195249342306398947555314564235580521011042660485419306492425693811105863163078246410p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492300p 0.9
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492310p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492800p -0.3
+ 28612366677489743219905759214096117683142981269602719314980517267579869681833468847093157393302425410816813317958343611817588871001610558720356766900211343241707601327426764258555420774626387784250518522289781694368390498684612797895110629128471161042022085320970838612984851387622211726326156492810p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985100p 0.9
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985110p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985600p -0.3
+ 57224733354979486439811518428192235366285962539205438629961034535159739363666937694186314786604850821633626635916687223635177742003221117440713533800422686483415202654853528517110841549252775568501037044579563388736780997369225595790221258256942322084044170641941677225969702775244423452652312985610p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970700p 0.9
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625970710p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971200p -0.3
+ 114449466709958972879623036856384470732571925078410877259922069070319478727333875388372629573209701643267253271833374447270355484006442234881427067600845372966830405309707057034221683098505551137002074089159126777473561994738451191580442516513884644168088341283883354451939405550488846905304625971210p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941900p 0.9
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251941910p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942400p -0.3
+ 228898933419917945759246073712768941465143850156821754519844138140638957454667750776745259146419403286534506543666748894540710968012884469762854135201690745933660810619414114068443366197011102274004148178318253554947123989476902383160885033027769288336176682567766708903878811100977693810609251942410p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884300p 0.9
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884310p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884800p -0.3
+ 457797866839835891518492147425537882930287700313643509039688276281277914909335501553490518292838806573069013087333497789081421936025768939525708270403381491867321621238828228136886732394022204548008296356636507109894247978953804766321770066055538576672353365135533417807757622201955387621218503884810p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769100p 0.9
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769110p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769600p -0.3
+ 915595733679671783036984294851075765860575400627287018079376552562555829818671003106981036585677613146138026174666995578162843872051537879051416540806762983734643242477656456273773464788044409096016592713273014219788495957907609532643540132111077153344706730271066835615515244403910775242437007769610p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538700p 0.9
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015538710p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539200p -0.3
+ 1831191467359343566073968589702151531721150801254574036158753105125111659637342006213962073171355226292276052349333991156325687744103075758102833081613525967469286484955312912547546929576088818192033185426546028439576991915815219065287080264222154306689413460542133671231030488807821550484874015539210p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077900p 0.9
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031077910p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078400p -0.3
+ 3662382934718687132147937179404303063442301602509148072317506210250223319274684012427924146342710452584552104698667982312651375488206151516205666163227051934938572969910625825095093859152177636384066370853092056879153983831630438130574160528444308613378826921084267342462060977615643100969748031078410p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156300p 0.9
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156310p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156800p -0.3
+ 7324765869437374264295874358808606126884603205018296144635012420500446638549368024855848292685420905169104209397335964625302750976412303032411332326454103869877145939821251650190187718304355272768132741706184113758307967663260876261148321056888617226757653842168534684924121955231286201939496062156810p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313100p 0.9
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313110p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313600p -0.3
+ 14649531738874748528591748717617212253769206410036592289270024841000893277098736049711696585370841810338208418794671929250605501952824606064822664652908207739754291879642503300380375436608710545536265483412368227516615935326521752522296642113777234453515307684337069369848243910462572403878992124313610p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626700p 0.9
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248626710p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627200p -0.3
+ 29299063477749497057183497435234424507538412820073184578540049682001786554197472099423393170741683620676416837589343858501211003905649212129645329305816415479508583759285006600760750873217421091072530966824736455033231870653043505044593284227554468907030615368674138739696487820925144807757984248627210p 0.9
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253900p 0.9
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497253910p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254400p -0.3
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254410p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508300p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508310p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508800p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508810p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017100p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017110p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017600p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017610p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034700p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034710p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035200p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035210p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069900p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069910p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070400p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070410p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140300p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140310p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140800p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140810p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281100p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281110p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281600p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281610p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562700p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562710p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563200p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563210p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125900p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125910p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126400p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126410p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252300p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252310p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252800p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252810p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505100p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505110p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505600p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505610p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010700p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010710p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011200p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011210p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021900p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021910p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022400p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022410p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044300p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044310p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044800p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044810p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089100p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089110p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089600p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089610p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178700p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178710p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179200p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179210p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357900p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357910p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358400p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358410p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716300p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716310p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716800p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716810p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433100p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433110p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433600p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433610p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866700p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866710p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867200p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867210p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733900p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733910p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734400p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734410p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468300p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468310p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468800p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468810p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937100p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937110p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937600p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937610p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874700p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874710p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875200p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875210p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749900p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749910p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750400p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750410p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500300p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500310p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500800p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500810p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001100p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001110p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001600p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001610p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002700p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002710p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003200p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003210p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005900p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005910p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006400p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006410p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012300p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012310p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012800p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012810p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025100p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025110p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025600p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025610p 0.9
+ \]
V_clk   (clk gnd!)     vsource type=pwl wave=\[
+ 0    -0.3
+ 200p -0.3
+ 210p 0.9
+ 700p 0.9
+ 710p -0.3
+ 900p -0.3
+ 910p 0.9
+ 1400p 0.9
+ 1410p -0.3
+ 2300p -0.3
+ 2310p 0.9
+ 2800p 0.9
+ 2810p -0.3
+ 5100p -0.3
+ 5110p 0.9
+ 5600p 0.9
+ 5610p -0.3
+ 10700p -0.3
+ 10710p 0.9
+ 11200p 0.9
+ 11210p -0.3
+ 21900p -0.3
+ 21910p 0.9
+ 22400p 0.9
+ 22410p -0.3
+ 44300p -0.3
+ 44310p 0.9
+ 44800p 0.9
+ 44810p -0.3
+ 89100p -0.3
+ 89110p 0.9
+ 89600p 0.9
+ 89610p -0.3
+ 178700p -0.3
+ 178710p 0.9
+ 179200p 0.9
+ 179210p -0.3
+ 357900p -0.3
+ 357910p 0.9
+ 358400p 0.9
+ 358410p -0.3
+ 716300p -0.3
+ 716310p 0.9
+ 716800p 0.9
+ 716810p -0.3
+ 1433100p -0.3
+ 1433110p 0.9
+ 1433600p 0.9
+ 1433610p -0.3
+ 2866700p -0.3
+ 2866710p 0.9
+ 2867200p 0.9
+ 2867210p -0.3
+ 5733900p -0.3
+ 5733910p 0.9
+ 5734400p 0.9
+ 5734410p -0.3
+ 11468300p -0.3
+ 11468310p 0.9
+ 11468800p 0.9
+ 11468810p -0.3
+ 22937100p -0.3
+ 22937110p 0.9
+ 22937600p 0.9
+ 22937610p -0.3
+ 45874700p -0.3
+ 45874710p 0.9
+ 45875200p 0.9
+ 45875210p -0.3
+ 91749900p -0.3
+ 91749910p 0.9
+ 91750400p 0.9
+ 91750410p -0.3
+ 183500300p -0.3
+ 183500310p 0.9
+ 183500800p 0.9
+ 183500810p -0.3
+ 367001100p -0.3
+ 367001110p 0.9
+ 367001600p 0.9
+ 367001610p -0.3
+ 734002700p -0.3
+ 734002710p 0.9
+ 734003200p 0.9
+ 734003210p -0.3
+ 1468005900p -0.3
+ 1468005910p 0.9
+ 1468006400p 0.9
+ 1468006410p -0.3
+ 2936012300p -0.3
+ 2936012310p 0.9
+ 2936012800p 0.9
+ 2936012810p -0.3
+ 5872025100p -0.3
+ 5872025110p 0.9
+ 5872025600p 0.9
+ 5872025610p -0.3
+ 11744050700p -0.3
+ 11744050710p 0.9
+ 11744051200p 0.9
+ 11744051210p -0.3
+ 23488101900p -0.3
+ 23488101910p 0.9
+ 23488102400p 0.9
+ 23488102410p -0.3
+ 46976204300p -0.3
+ 46976204310p 0.9
+ 46976204800p 0.9
+ 46976204810p -0.3
+ 93952409100p -0.3
+ 93952409110p 0.9
+ 93952409600p 0.9
+ 93952409610p -0.3
+ 187904818700p -0.3
+ 187904818710p 0.9
+ 187904819200p 0.9
+ 187904819210p -0.3
+ 375809637900p -0.3
+ 375809637910p 0.9
+ 375809638400p 0.9
+ 375809638410p -0.3
+ 751619276300p -0.3
+ 751619276310p 0.9
+ 751619276800p 0.9
+ 751619276810p -0.3
+ 1503238553100p -0.3
+ 1503238553110p 0.9
+ 1503238553600p 0.9
+ 1503238553610p -0.3
+ 3006477106700p -0.3
+ 3006477106710p 0.9
+ 3006477107200p 0.9
+ 3006477107210p -0.3
+ 6012954213900p -0.3
+ 6012954213910p 0.9
+ 6012954214400p 0.9
+ 6012954214410p -0.3
+ 12025908428300p -0.3
+ 12025908428310p 0.9
+ 12025908428800p 0.9
+ 12025908428810p -0.3
+ 24051816857100p -0.3
+ 24051816857110p 0.9
+ 24051816857600p 0.9
+ 24051816857610p -0.3
+ 48103633714700p -0.3
+ 48103633714710p 0.9
+ 48103633715200p 0.9
+ 48103633715210p -0.3
+ 96207267429900p -0.3
+ 96207267429910p 0.9
+ 96207267430400p 0.9
+ 96207267430410p -0.3
+ 192414534860300p -0.3
+ 192414534860310p 0.9
+ 192414534860800p 0.9
+ 192414534860810p -0.3
+ 384829069721100p -0.3
+ 384829069721110p 0.9
+ 384829069721600p 0.9
+ 384829069721610p -0.3
+ 769658139442700p -0.3
+ 769658139442710p 0.9
+ 769658139443200p 0.9
+ 769658139443210p -0.3
+ 1539316278885900p -0.3
+ 1539316278885910p 0.9
+ 1539316278886400p 0.9
+ 1539316278886410p -0.3
+ 3078632557772300p -0.3
+ 3078632557772310p 0.9
+ 3078632557772800p 0.9
+ 3078632557772810p -0.3
+ 6157265115545100p -0.3
+ 6157265115545110p 0.9
+ 6157265115545600p 0.9
+ 6157265115545610p -0.3
+ 12314530231090700p -0.3
+ 12314530231090710p 0.9
+ 12314530231091200p 0.9
+ 12314530231091210p -0.3
+ 24629060462181900p -0.3
+ 24629060462181910p 0.9
+ 24629060462182400p 0.9
+ 24629060462182410p -0.3
+ 49258120924364300p -0.3
+ 49258120924364310p 0.9
+ 49258120924364800p 0.9
+ 49258120924364810p -0.3
+ 98516241848729100p -0.3
+ 98516241848729110p 0.9
+ 98516241848729600p 0.9
+ 98516241848729610p -0.3
+ 197032483697458700p -0.3
+ 197032483697458710p 0.9
+ 197032483697459200p 0.9
+ 197032483697459210p -0.3
+ 394064967394917900p -0.3
+ 394064967394917910p 0.9
+ 394064967394918400p 0.9
+ 394064967394918410p -0.3
+ 788129934789836300p -0.3
+ 788129934789836310p 0.9
+ 788129934789836800p 0.9
+ 788129934789836810p -0.3
+ 1576259869579673100p -0.3
+ 1576259869579673110p 0.9
+ 1576259869579673600p 0.9
+ 1576259869579673610p -0.3
+ 3152519739159346700p -0.3
+ 3152519739159346710p 0.9
+ 3152519739159347200p 0.9
+ 3152519739159347210p -0.3
+ 6305039478318693900p -0.3
+ 6305039478318693910p 0.9
+ 6305039478318694400p 0.9
+ 6305039478318694410p -0.3
+ 12610078956637388300p -0.3
+ 12610078956637388310p 0.9
+ 12610078956637388800p 0.9
+ 12610078956637388810p -0.3
+ 25220157913274777100p -0.3
+ 25220157913274777110p 0.9
+ 25220157913274777600p 0.9
+ 25220157913274777610p -0.3
+ 50440315826549554700p -0.3
+ 50440315826549554710p 0.9
+ 50440315826549555200p 0.9
+ 50440315826549555210p -0.3
+ 100880631653099109900p -0.3
+ 100880631653099109910p 0.9
+ 100880631653099110400p 0.9
+ 100880631653099110410p -0.3
+ 201761263306198220300p -0.3
+ 201761263306198220310p 0.9
+ 201761263306198220800p 0.9
+ 201761263306198220810p -0.3
+ 403522526612396441100p -0.3
+ 403522526612396441110p 0.9
+ 403522526612396441600p 0.9
+ 403522526612396441610p -0.3
+ 807045053224792882700p -0.3
+ 807045053224792882710p 0.9
+ 807045053224792883200p 0.9
+ 807045053224792883210p -0.3
+ 1614090106449585765900p -0.3
+ 1614090106449585765910p 0.9
+ 1614090106449585766400p 0.9
+ 1614090106449585766410p -0.3
+ 3228180212899171532300p -0.3
+ 3228180212899171532310p 0.9
+ 3228180212899171532800p 0.9
+ 3228180212899171532810p -0.3
+ 6456360425798343065100p -0.3
+ 6456360425798343065110p 0.9
+ 6456360425798343065600p 0.9
+ 6456360425798343065610p -0.3
+ 12912720851596686130700p -0.3
+ 12912720851596686130710p 0.9
+ 12912720851596686131200p 0.9
+ 12912720851596686131210p -0.3
+ 25825441703193372261900p -0.3
+ 25825441703193372261910p 0.9
+ 25825441703193372262400p 0.9
+ 25825441703193372262410p -0.3
+ 51650883406386744524300p -0.3
+ 51650883406386744524310p 0.9
+ 51650883406386744524800p 0.9
+ 51650883406386744524810p -0.3
+ 103301766812773489049100p -0.3
+ 103301766812773489049110p 0.9
+ 103301766812773489049600p 0.9
+ 103301766812773489049610p -0.3
+ 206603533625546978098700p -0.3
+ 206603533625546978098710p 0.9
+ 206603533625546978099200p 0.9
+ 206603533625546978099210p -0.3
+ 413207067251093956197900p -0.3
+ 413207067251093956197910p 0.9
+ 413207067251093956198400p 0.9
+ 413207067251093956198410p -0.3
+ 826414134502187912396300p -0.3
+ 826414134502187912396310p 0.9
+ 826414134502187912396800p 0.9
+ 826414134502187912396810p -0.3
+ 1652828269004375824793100p -0.3
+ 1652828269004375824793110p 0.9
+ 1652828269004375824793600p 0.9
+ 1652828269004375824793610p -0.3
+ 3305656538008751649586700p -0.3
+ 3305656538008751649586710p 0.9
+ 3305656538008751649587200p 0.9
+ 3305656538008751649587210p -0.3
+ 6611313076017503299173900p -0.3
+ 6611313076017503299173910p 0.9
+ 6611313076017503299174400p 0.9
+ 6611313076017503299174410p -0.3
+ 13222626152035006598348300p -0.3
+ 13222626152035006598348310p 0.9
+ 13222626152035006598348800p 0.9
+ 13222626152035006598348810p -0.3
+ 26445252304070013196697100p -0.3
+ 26445252304070013196697110p 0.9
+ 26445252304070013196697600p 0.9
+ 26445252304070013196697610p -0.3
+ 52890504608140026393394700p -0.3
+ 52890504608140026393394710p 0.9
+ 52890504608140026393395200p 0.9
+ 52890504608140026393395210p -0.3
+ 105781009216280052786789900p -0.3
+ 105781009216280052786789910p 0.9
+ 105781009216280052786790400p 0.9
+ 105781009216280052786790410p -0.3
+ 211562018432560105573580300p -0.3
+ 211562018432560105573580310p 0.9
+ 211562018432560105573580800p 0.9
+ 211562018432560105573580810p -0.3
+ 423124036865120211147161100p -0.3
+ 423124036865120211147161110p 0.9
+ 423124036865120211147161600p 0.9
+ 423124036865120211147161610p -0.3
+ 846248073730240422294322700p -0.3
+ 846248073730240422294322710p 0.9
+ 846248073730240422294323200p 0.9
+ 846248073730240422294323210p -0.3
+ 1692496147460480844588645900p -0.3
+ 1692496147460480844588645910p 0.9
+ 1692496147460480844588646400p 0.9
+ 1692496147460480844588646410p -0.3
+ 3384992294920961689177292300p -0.3
+ 3384992294920961689177292310p 0.9
+ 3384992294920961689177292800p 0.9
+ 3384992294920961689177292810p -0.3
+ 6769984589841923378354585100p -0.3
+ 6769984589841923378354585110p 0.9
+ 6769984589841923378354585600p 0.9
+ 6769984589841923378354585610p -0.3
+ 13539969179683846756709170700p -0.3
+ 13539969179683846756709170710p 0.9
+ 13539969179683846756709171200p 0.9
+ 13539969179683846756709171210p -0.3
+ 27079938359367693513418341900p -0.3
+ 27079938359367693513418341910p 0.9
+ 27079938359367693513418342400p 0.9
+ 27079938359367693513418342410p -0.3
+ 54159876718735387026836684300p -0.3
+ 54159876718735387026836684310p 0.9
+ 54159876718735387026836684800p 0.9
+ 54159876718735387026836684810p -0.3
+ 108319753437470774053673369100p -0.3
+ 108319753437470774053673369110p 0.9
+ 108319753437470774053673369600p 0.9
+ 108319753437470774053673369610p -0.3
+ 216639506874941548107346738700p -0.3
+ 216639506874941548107346738710p 0.9
+ 216639506874941548107346739200p 0.9
+ 216639506874941548107346739210p -0.3
+ 433279013749883096214693477900p -0.3
+ 433279013749883096214693477910p 0.9
+ 433279013749883096214693478400p 0.9
+ 433279013749883096214693478410p -0.3
+ 866558027499766192429386956300p -0.3
+ 866558027499766192429386956310p 0.9
+ 866558027499766192429386956800p 0.9
+ 866558027499766192429386956810p -0.3
+ 1733116054999532384858773913100p -0.3
+ 1733116054999532384858773913110p 0.9
+ 1733116054999532384858773913600p 0.9
+ 1733116054999532384858773913610p -0.3
+ 3466232109999064769717547826700p -0.3
+ 3466232109999064769717547826710p 0.9
+ 3466232109999064769717547827200p 0.9
+ 3466232109999064769717547827210p -0.3
+ 6932464219998129539435095653900p -0.3
+ 6932464219998129539435095653910p 0.9
+ 6932464219998129539435095654400p 0.9
+ 6932464219998129539435095654410p -0.3
+ 13864928439996259078870191308300p -0.3
+ 13864928439996259078870191308310p 0.9
+ 13864928439996259078870191308800p 0.9
+ 13864928439996259078870191308810p -0.3
+ 27729856879992518157740382617100p -0.3
+ 27729856879992518157740382617110p 0.9
+ 27729856879992518157740382617600p 0.9
+ 27729856879992518157740382617610p -0.3
+ 55459713759985036315480765234700p -0.3
+ 55459713759985036315480765234710p 0.9
+ 55459713759985036315480765235200p 0.9
+ 55459713759985036315480765235210p -0.3
+ 110919427519970072630961530469900p -0.3
+ 110919427519970072630961530469910p 0.9
+ 110919427519970072630961530470400p 0.9
+ 110919427519970072630961530470410p -0.3
+ 221838855039940145261923060940300p -0.3
+ 221838855039940145261923060940310p 0.9
+ 221838855039940145261923060940800p 0.9
+ 221838855039940145261923060940810p -0.3
+ 443677710079880290523846121881100p -0.3
+ 443677710079880290523846121881110p 0.9
+ 443677710079880290523846121881600p 0.9
+ 443677710079880290523846121881610p -0.3
+ 887355420159760581047692243762700p -0.3
+ 887355420159760581047692243762710p 0.9
+ 887355420159760581047692243763200p 0.9
+ 887355420159760581047692243763210p -0.3
+ 1774710840319521162095384487525900p -0.3
+ 1774710840319521162095384487525910p 0.9
+ 1774710840319521162095384487526400p 0.9
+ 1774710840319521162095384487526410p -0.3
+ 3549421680639042324190768975052300p -0.3
+ 3549421680639042324190768975052310p 0.9
+ 3549421680639042324190768975052800p 0.9
+ 3549421680639042324190768975052810p -0.3
+ 7098843361278084648381537950105100p -0.3
+ 7098843361278084648381537950105110p 0.9
+ 7098843361278084648381537950105600p 0.9
+ 7098843361278084648381537950105610p -0.3
+ 14197686722556169296763075900210700p -0.3
+ 14197686722556169296763075900210710p 0.9
+ 14197686722556169296763075900211200p 0.9
+ 14197686722556169296763075900211210p -0.3
+ 28395373445112338593526151800421900p -0.3
+ 28395373445112338593526151800421910p 0.9
+ 28395373445112338593526151800422400p 0.9
+ 28395373445112338593526151800422410p -0.3
+ 56790746890224677187052303600844300p -0.3
+ 56790746890224677187052303600844310p 0.9
+ 56790746890224677187052303600844800p 0.9
+ 56790746890224677187052303600844810p -0.3
+ 113581493780449354374104607201689100p -0.3
+ 113581493780449354374104607201689110p 0.9
+ 113581493780449354374104607201689600p 0.9
+ 113581493780449354374104607201689610p -0.3
+ 227162987560898708748209214403378700p -0.3
+ 227162987560898708748209214403378710p 0.9
+ 227162987560898708748209214403379200p 0.9
+ 227162987560898708748209214403379210p -0.3
+ 454325975121797417496418428806757900p -0.3
+ 454325975121797417496418428806757910p 0.9
+ 454325975121797417496418428806758400p 0.9
+ 454325975121797417496418428806758410p -0.3
+ 908651950243594834992836857613516300p -0.3
+ 908651950243594834992836857613516310p 0.9
+ 908651950243594834992836857613516800p 0.9
+ 908651950243594834992836857613516810p -0.3
+ 1817303900487189669985673715227033100p -0.3
+ 1817303900487189669985673715227033110p 0.9
+ 1817303900487189669985673715227033600p 0.9
+ 1817303900487189669985673715227033610p -0.3
+ 3634607800974379339971347430454066700p -0.3
+ 3634607800974379339971347430454066710p 0.9
+ 3634607800974379339971347430454067200p 0.9
+ 3634607800974379339971347430454067210p -0.3
+ 7269215601948758679942694860908133900p -0.3
+ 7269215601948758679942694860908133910p 0.9
+ 7269215601948758679942694860908134400p 0.9
+ 7269215601948758679942694860908134410p -0.3
+ 14538431203897517359885389721816268300p -0.3
+ 14538431203897517359885389721816268310p 0.9
+ 14538431203897517359885389721816268800p 0.9
+ 14538431203897517359885389721816268810p -0.3
+ 29076862407795034719770779443632537100p -0.3
+ 29076862407795034719770779443632537110p 0.9
+ 29076862407795034719770779443632537600p 0.9
+ 29076862407795034719770779443632537610p -0.3
+ 58153724815590069439541558887265074700p -0.3
+ 58153724815590069439541558887265074710p 0.9
+ 58153724815590069439541558887265075200p 0.9
+ 58153724815590069439541558887265075210p -0.3
+ 116307449631180138879083117774530149900p -0.3
+ 116307449631180138879083117774530149910p 0.9
+ 116307449631180138879083117774530150400p 0.9
+ 116307449631180138879083117774530150410p -0.3
+ 232614899262360277758166235549060300300p -0.3
+ 232614899262360277758166235549060300310p 0.9
+ 232614899262360277758166235549060300800p 0.9
+ 232614899262360277758166235549060300810p -0.3
+ 465229798524720555516332471098120601100p -0.3
+ 465229798524720555516332471098120601110p 0.9
+ 465229798524720555516332471098120601600p 0.9
+ 465229798524720555516332471098120601610p -0.3
+ 930459597049441111032664942196241202700p -0.3
+ 930459597049441111032664942196241202710p 0.9
+ 930459597049441111032664942196241203200p 0.9
+ 930459597049441111032664942196241203210p -0.3
+ 1860919194098882222065329884392482405900p -0.3
+ 1860919194098882222065329884392482405910p 0.9
+ 1860919194098882222065329884392482406400p 0.9
+ 1860919194098882222065329884392482406410p -0.3
+ 3721838388197764444130659768784964812300p -0.3
+ 3721838388197764444130659768784964812310p 0.9
+ 3721838388197764444130659768784964812800p 0.9
+ 3721838388197764444130659768784964812810p -0.3
+ 7443676776395528888261319537569929625100p -0.3
+ 7443676776395528888261319537569929625110p 0.9
+ 7443676776395528888261319537569929625600p 0.9
+ 7443676776395528888261319537569929625610p -0.3
+ 14887353552791057776522639075139859250700p -0.3
+ 14887353552791057776522639075139859250710p 0.9
+ 14887353552791057776522639075139859251200p 0.9
+ 14887353552791057776522639075139859251210p -0.3
+ 29774707105582115553045278150279718501900p -0.3
+ 29774707105582115553045278150279718501910p 0.9
+ 29774707105582115553045278150279718502400p 0.9
+ 29774707105582115553045278150279718502410p -0.3
+ 59549414211164231106090556300559437004300p -0.3
+ 59549414211164231106090556300559437004310p 0.9
+ 59549414211164231106090556300559437004800p 0.9
+ 59549414211164231106090556300559437004810p -0.3
+ 119098828422328462212181112601118874009100p -0.3
+ 119098828422328462212181112601118874009110p 0.9
+ 119098828422328462212181112601118874009600p 0.9
+ 119098828422328462212181112601118874009610p -0.3
+ 238197656844656924424362225202237748018700p -0.3
+ 238197656844656924424362225202237748018710p 0.9
+ 238197656844656924424362225202237748019200p 0.9
+ 238197656844656924424362225202237748019210p -0.3
+ 476395313689313848848724450404475496037900p -0.3
+ 476395313689313848848724450404475496037910p 0.9
+ 476395313689313848848724450404475496038400p 0.9
+ 476395313689313848848724450404475496038410p -0.3
+ 952790627378627697697448900808950992076300p -0.3
+ 952790627378627697697448900808950992076310p 0.9
+ 952790627378627697697448900808950992076800p 0.9
+ 952790627378627697697448900808950992076810p -0.3
+ 1905581254757255395394897801617901984153100p -0.3
+ 1905581254757255395394897801617901984153110p 0.9
+ 1905581254757255395394897801617901984153600p 0.9
+ 1905581254757255395394897801617901984153610p -0.3
+ 3811162509514510790789795603235803968306700p -0.3
+ 3811162509514510790789795603235803968306710p 0.9
+ 3811162509514510790789795603235803968307200p 0.9
+ 3811162509514510790789795603235803968307210p -0.3
+ 7622325019029021581579591206471607936613900p -0.3
+ 7622325019029021581579591206471607936613910p 0.9
+ 7622325019029021581579591206471607936614400p 0.9
+ 7622325019029021581579591206471607936614410p -0.3
+ 15244650038058043163159182412943215873228300p -0.3
+ 15244650038058043163159182412943215873228310p 0.9
+ 15244650038058043163159182412943215873228800p 0.9
+ 15244650038058043163159182412943215873228810p -0.3
+ 30489300076116086326318364825886431746457100p -0.3
+ 30489300076116086326318364825886431746457110p 0.9
+ 30489300076116086326318364825886431746457600p 0.9
+ 30489300076116086326318364825886431746457610p -0.3
+ 60978600152232172652636729651772863492914700p -0.3
+ 60978600152232172652636729651772863492914710p 0.9
+ 60978600152232172652636729651772863492915200p 0.9
+ 60978600152232172652636729651772863492915210p -0.3
+ 121957200304464345305273459303545726985829900p -0.3
+ 121957200304464345305273459303545726985829910p 0.9
+ 121957200304464345305273459303545726985830400p 0.9
+ 121957200304464345305273459303545726985830410p -0.3
+ 243914400608928690610546918607091453971660300p -0.3
+ 243914400608928690610546918607091453971660310p 0.9
+ 243914400608928690610546918607091453971660800p 0.9
+ 243914400608928690610546918607091453971660810p -0.3
+ 487828801217857381221093837214182907943321100p -0.3
+ 487828801217857381221093837214182907943321110p 0.9
+ 487828801217857381221093837214182907943321600p 0.9
+ 487828801217857381221093837214182907943321610p -0.3
+ 975657602435714762442187674428365815886642700p -0.3
+ 975657602435714762442187674428365815886642710p 0.9
+ 975657602435714762442187674428365815886643200p 0.9
+ 975657602435714762442187674428365815886643210p -0.3
+ 1951315204871429524884375348856731631773285900p -0.3
+ 1951315204871429524884375348856731631773285910p 0.9
+ 1951315204871429524884375348856731631773286400p 0.9
+ 1951315204871429524884375348856731631773286410p -0.3
+ 3902630409742859049768750697713463263546572300p -0.3
+ 3902630409742859049768750697713463263546572310p 0.9
+ 3902630409742859049768750697713463263546572800p 0.9
+ 3902630409742859049768750697713463263546572810p -0.3
+ 7805260819485718099537501395426926527093145100p -0.3
+ 7805260819485718099537501395426926527093145110p 0.9
+ 7805260819485718099537501395426926527093145600p 0.9
+ 7805260819485718099537501395426926527093145610p -0.3
+ 15610521638971436199075002790853853054186290700p -0.3
+ 15610521638971436199075002790853853054186290710p 0.9
+ 15610521638971436199075002790853853054186291200p 0.9
+ 15610521638971436199075002790853853054186291210p -0.3
+ 31221043277942872398150005581707706108372581900p -0.3
+ 31221043277942872398150005581707706108372581910p 0.9
+ 31221043277942872398150005581707706108372582400p 0.9
+ 31221043277942872398150005581707706108372582410p -0.3
+ 62442086555885744796300011163415412216745164300p -0.3
+ 62442086555885744796300011163415412216745164310p 0.9
+ 62442086555885744796300011163415412216745164800p 0.9
+ 62442086555885744796300011163415412216745164810p -0.3
+ 124884173111771489592600022326830824433490329100p -0.3
+ 124884173111771489592600022326830824433490329110p 0.9
+ 124884173111771489592600022326830824433490329600p 0.9
+ 124884173111771489592600022326830824433490329610p -0.3
+ 249768346223542979185200044653661648866980658700p -0.3
+ 249768346223542979185200044653661648866980658710p 0.9
+ 249768346223542979185200044653661648866980659200p 0.9
+ 249768346223542979185200044653661648866980659210p -0.3
+ 499536692447085958370400089307323297733961317900p -0.3
+ 499536692447085958370400089307323297733961317910p 0.9
+ 499536692447085958370400089307323297733961318400p 0.9
+ 499536692447085958370400089307323297733961318410p -0.3
+ 999073384894171916740800178614646595467922636300p -0.3
+ 999073384894171916740800178614646595467922636310p 0.9
+ 999073384894171916740800178614646595467922636800p 0.9
+ 999073384894171916740800178614646595467922636810p -0.3
+ 1998146769788343833481600357229293190935845273100p -0.3
+ 1998146769788343833481600357229293190935845273110p 0.9
+ 1998146769788343833481600357229293190935845273600p 0.9
+ 1998146769788343833481600357229293190935845273610p -0.3
+ 3996293539576687666963200714458586381871690546700p -0.3
+ 3996293539576687666963200714458586381871690546710p 0.9
+ 3996293539576687666963200714458586381871690547200p 0.9
+ 3996293539576687666963200714458586381871690547210p -0.3
+ 7992587079153375333926401428917172763743381093900p -0.3
+ 7992587079153375333926401428917172763743381093910p 0.9
+ 7992587079153375333926401428917172763743381094400p 0.9
+ 7992587079153375333926401428917172763743381094410p -0.3
+ 15985174158306750667852802857834345527486762188300p -0.3
+ 15985174158306750667852802857834345527486762188310p 0.9
+ 15985174158306750667852802857834345527486762188800p 0.9
+ 15985174158306750667852802857834345527486762188810p -0.3
+ 31970348316613501335705605715668691054973524377100p -0.3
+ 31970348316613501335705605715668691054973524377110p 0.9
+ 31970348316613501335705605715668691054973524377600p 0.9
+ 31970348316613501335705605715668691054973524377610p -0.3
+ 63940696633227002671411211431337382109947048754700p -0.3
+ 63940696633227002671411211431337382109947048754710p 0.9
+ 63940696633227002671411211431337382109947048755200p 0.9
+ 63940696633227002671411211431337382109947048755210p -0.3
+ 127881393266454005342822422862674764219894097509900p -0.3
+ 127881393266454005342822422862674764219894097509910p 0.9
+ 127881393266454005342822422862674764219894097510400p 0.9
+ 127881393266454005342822422862674764219894097510410p -0.3
+ 255762786532908010685644845725349528439788195020300p -0.3
+ 255762786532908010685644845725349528439788195020310p 0.9
+ 255762786532908010685644845725349528439788195020800p 0.9
+ 255762786532908010685644845725349528439788195020810p -0.3
+ 511525573065816021371289691450699056879576390041100p -0.3
+ 511525573065816021371289691450699056879576390041110p 0.9
+ 511525573065816021371289691450699056879576390041600p 0.9
+ 511525573065816021371289691450699056879576390041610p -0.3
+ 1023051146131632042742579382901398113759152780082700p -0.3
+ 1023051146131632042742579382901398113759152780082710p 0.9
+ 1023051146131632042742579382901398113759152780083200p 0.9
+ 1023051146131632042742579382901398113759152780083210p -0.3
+ 2046102292263264085485158765802796227518305560165900p -0.3
+ 2046102292263264085485158765802796227518305560165910p 0.9
+ 2046102292263264085485158765802796227518305560166400p 0.9
+ 2046102292263264085485158765802796227518305560166410p -0.3
+ 4092204584526528170970317531605592455036611120332300p -0.3
+ 4092204584526528170970317531605592455036611120332310p 0.9
+ 4092204584526528170970317531605592455036611120332800p 0.9
+ 4092204584526528170970317531605592455036611120332810p -0.3
+ 8184409169053056341940635063211184910073222240665100p -0.3
+ 8184409169053056341940635063211184910073222240665110p 0.9
+ 8184409169053056341940635063211184910073222240665600p 0.9
+ 8184409169053056341940635063211184910073222240665610p -0.3
+ 16368818338106112683881270126422369820146444481330700p -0.3
+ 16368818338106112683881270126422369820146444481330710p 0.9
+ 16368818338106112683881270126422369820146444481331200p 0.9
+ 16368818338106112683881270126422369820146444481331210p -0.3
+ 32737636676212225367762540252844739640292888962661900p -0.3
+ 32737636676212225367762540252844739640292888962661910p 0.9
+ 32737636676212225367762540252844739640292888962662400p 0.9
+ 32737636676212225367762540252844739640292888962662410p -0.3
+ 65475273352424450735525080505689479280585777925324300p -0.3
+ 65475273352424450735525080505689479280585777925324310p 0.9
+ 65475273352424450735525080505689479280585777925324800p 0.9
+ 65475273352424450735525080505689479280585777925324810p -0.3
+ 130950546704848901471050161011378958561171555850649100p -0.3
+ 130950546704848901471050161011378958561171555850649110p 0.9
+ 130950546704848901471050161011378958561171555850649600p 0.9
+ 130950546704848901471050161011378958561171555850649610p -0.3
+ 261901093409697802942100322022757917122343111701298700p -0.3
+ 261901093409697802942100322022757917122343111701298710p 0.9
+ 261901093409697802942100322022757917122343111701299200p 0.9
+ 261901093409697802942100322022757917122343111701299210p -0.3
+ 523802186819395605884200644045515834244686223402597900p -0.3
+ 523802186819395605884200644045515834244686223402597910p 0.9
+ 523802186819395605884200644045515834244686223402598400p 0.9
+ 523802186819395605884200644045515834244686223402598410p -0.3
+ 1047604373638791211768401288091031668489372446805196300p -0.3
+ 1047604373638791211768401288091031668489372446805196310p 0.9
+ 1047604373638791211768401288091031668489372446805196800p 0.9
+ 1047604373638791211768401288091031668489372446805196810p -0.3
+ 2095208747277582423536802576182063336978744893610393100p -0.3
+ 2095208747277582423536802576182063336978744893610393110p 0.9
+ 2095208747277582423536802576182063336978744893610393600p 0.9
+ 2095208747277582423536802576182063336978744893610393610p -0.3
+ 4190417494555164847073605152364126673957489787220786700p -0.3
+ 4190417494555164847073605152364126673957489787220786710p 0.9
+ 4190417494555164847073605152364126673957489787220787200p 0.9
+ 4190417494555164847073605152364126673957489787220787210p -0.3
+ 8380834989110329694147210304728253347914979574441573900p -0.3
+ 8380834989110329694147210304728253347914979574441573910p 0.9
+ 8380834989110329694147210304728253347914979574441574400p 0.9
+ 8380834989110329694147210304728253347914979574441574410p -0.3
+ 16761669978220659388294420609456506695829959148883148300p -0.3
+ 16761669978220659388294420609456506695829959148883148310p 0.9
+ 16761669978220659388294420609456506695829959148883148800p 0.9
+ 16761669978220659388294420609456506695829959148883148810p -0.3
+ 33523339956441318776588841218913013391659918297766297100p -0.3
+ 33523339956441318776588841218913013391659918297766297110p 0.9
+ 33523339956441318776588841218913013391659918297766297600p 0.9
+ 33523339956441318776588841218913013391659918297766297610p -0.3
+ 67046679912882637553177682437826026783319836595532594700p -0.3
+ 67046679912882637553177682437826026783319836595532594710p 0.9
+ 67046679912882637553177682437826026783319836595532595200p 0.9
+ 67046679912882637553177682437826026783319836595532595210p -0.3
+ 134093359825765275106355364875652053566639673191065189900p -0.3
+ 134093359825765275106355364875652053566639673191065189910p 0.9
+ 134093359825765275106355364875652053566639673191065190400p 0.9
+ 134093359825765275106355364875652053566639673191065190410p -0.3
+ 268186719651530550212710729751304107133279346382130380300p -0.3
+ 268186719651530550212710729751304107133279346382130380310p 0.9
+ 268186719651530550212710729751304107133279346382130380800p 0.9
+ 268186719651530550212710729751304107133279346382130380810p -0.3
+ 536373439303061100425421459502608214266558692764260761100p -0.3
+ 536373439303061100425421459502608214266558692764260761110p 0.9
+ 536373439303061100425421459502608214266558692764260761600p 0.9
+ 536373439303061100425421459502608214266558692764260761610p -0.3
+ 1072746878606122200850842919005216428533117385528521522700p -0.3
+ 1072746878606122200850842919005216428533117385528521522710p 0.9
+ 1072746878606122200850842919005216428533117385528521523200p 0.9
+ 1072746878606122200850842919005216428533117385528521523210p -0.3
+ 2145493757212244401701685838010432857066234771057043045900p -0.3
+ 2145493757212244401701685838010432857066234771057043045910p 0.9
+ 2145493757212244401701685838010432857066234771057043046400p 0.9
+ 2145493757212244401701685838010432857066234771057043046410p -0.3
+ 4290987514424488803403371676020865714132469542114086092300p -0.3
+ 4290987514424488803403371676020865714132469542114086092310p 0.9
+ 4290987514424488803403371676020865714132469542114086092800p 0.9
+ 4290987514424488803403371676020865714132469542114086092810p -0.3
+ 8581975028848977606806743352041731428264939084228172185100p -0.3
+ 8581975028848977606806743352041731428264939084228172185110p 0.9
+ 8581975028848977606806743352041731428264939084228172185600p 0.9
+ 8581975028848977606806743352041731428264939084228172185610p -0.3
+ 17163950057697955213613486704083462856529878168456344370700p -0.3
+ 17163950057697955213613486704083462856529878168456344370710p 0.9
+ 17163950057697955213613486704083462856529878168456344371200p 0.9
+ 17163950057697955213613486704083462856529878168456344371210p -0.3
+ 34327900115395910427226973408166925713059756336912688741900p -0.3
+ 34327900115395910427226973408166925713059756336912688741910p 0.9
+ 34327900115395910427226973408166925713059756336912688742400p 0.9
+ 34327900115395910427226973408166925713059756336912688742410p -0.3
+ 68655800230791820854453946816333851426119512673825377484300p -0.3
+ 68655800230791820854453946816333851426119512673825377484310p 0.9
+ 68655800230791820854453946816333851426119512673825377484800p 0.9
+ 68655800230791820854453946816333851426119512673825377484810p -0.3
+ 137311600461583641708907893632667702852239025347650754969100p -0.3
+ 137311600461583641708907893632667702852239025347650754969110p 0.9
+ 137311600461583641708907893632667702852239025347650754969600p 0.9
+ 137311600461583641708907893632667702852239025347650754969610p -0.3
+ 274623200923167283417815787265335405704478050695301509938700p -0.3
+ 274623200923167283417815787265335405704478050695301509938710p 0.9
+ 274623200923167283417815787265335405704478050695301509939200p 0.9
+ 274623200923167283417815787265335405704478050695301509939210p -0.3
+ 549246401846334566835631574530670811408956101390603019877900p -0.3
+ 549246401846334566835631574530670811408956101390603019877910p 0.9
+ 549246401846334566835631574530670811408956101390603019878400p 0.9
+ 549246401846334566835631574530670811408956101390603019878410p -0.3
+ 1098492803692669133671263149061341622817912202781206039756300p -0.3
+ 1098492803692669133671263149061341622817912202781206039756310p 0.9
+ 1098492803692669133671263149061341622817912202781206039756800p 0.9
+ 1098492803692669133671263149061341622817912202781206039756810p -0.3
+ 2196985607385338267342526298122683245635824405562412079513100p -0.3
+ 2196985607385338267342526298122683245635824405562412079513110p 0.9
+ 2196985607385338267342526298122683245635824405562412079513600p 0.9
+ 2196985607385338267342526298122683245635824405562412079513610p -0.3
+ 4393971214770676534685052596245366491271648811124824159026700p -0.3
+ 4393971214770676534685052596245366491271648811124824159026710p 0.9
+ 4393971214770676534685052596245366491271648811124824159027200p 0.9
+ 4393971214770676534685052596245366491271648811124824159027210p -0.3
+ 8787942429541353069370105192490732982543297622249648318053900p -0.3
+ 8787942429541353069370105192490732982543297622249648318053910p 0.9
+ 8787942429541353069370105192490732982543297622249648318054400p 0.9
+ 8787942429541353069370105192490732982543297622249648318054410p -0.3
+ 17575884859082706138740210384981465965086595244499296636108300p -0.3
+ 17575884859082706138740210384981465965086595244499296636108310p 0.9
+ 17575884859082706138740210384981465965086595244499296636108800p 0.9
+ 17575884859082706138740210384981465965086595244499296636108810p -0.3
+ 35151769718165412277480420769962931930173190488998593272217100p -0.3
+ 35151769718165412277480420769962931930173190488998593272217110p 0.9
+ 35151769718165412277480420769962931930173190488998593272217600p 0.9
+ 35151769718165412277480420769962931930173190488998593272217610p -0.3
+ 70303539436330824554960841539925863860346380977997186544434700p -0.3
+ 70303539436330824554960841539925863860346380977997186544434710p 0.9
+ 70303539436330824554960841539925863860346380977997186544435200p 0.9
+ 70303539436330824554960841539925863860346380977997186544435210p -0.3
+ 140607078872661649109921683079851727720692761955994373088869900p -0.3
+ 140607078872661649109921683079851727720692761955994373088869910p 0.9
+ 140607078872661649109921683079851727720692761955994373088870400p 0.9
+ 140607078872661649109921683079851727720692761955994373088870410p -0.3
+ 281214157745323298219843366159703455441385523911988746177740300p -0.3
+ 281214157745323298219843366159703455441385523911988746177740310p 0.9
+ 281214157745323298219843366159703455441385523911988746177740800p 0.9
+ 281214157745323298219843366159703455441385523911988746177740810p -0.3
+ 562428315490646596439686732319406910882771047823977492355481100p -0.3
+ 562428315490646596439686732319406910882771047823977492355481110p 0.9
+ 562428315490646596439686732319406910882771047823977492355481600p 0.9
+ 562428315490646596439686732319406910882771047823977492355481610p -0.3
+ 1124856630981293192879373464638813821765542095647954984710962700p -0.3
+ 1124856630981293192879373464638813821765542095647954984710962710p 0.9
+ 1124856630981293192879373464638813821765542095647954984710963200p 0.9
+ 1124856630981293192879373464638813821765542095647954984710963210p -0.3
+ 2249713261962586385758746929277627643531084191295909969421925900p -0.3
+ 2249713261962586385758746929277627643531084191295909969421925910p 0.9
+ 2249713261962586385758746929277627643531084191295909969421926400p 0.9
+ 2249713261962586385758746929277627643531084191295909969421926410p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852300p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852310p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852800p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852810p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705100p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705110p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705600p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705610p -0.3
+ 17997706095700691086069975434221021148248673530367279755375410700p -0.3
+ 17997706095700691086069975434221021148248673530367279755375410710p 0.9
+ 17997706095700691086069975434221021148248673530367279755375411200p 0.9
+ 17997706095700691086069975434221021148248673530367279755375411210p -0.3
+ 35995412191401382172139950868442042296497347060734559510750821900p -0.3
+ 35995412191401382172139950868442042296497347060734559510750821910p 0.9
+ 35995412191401382172139950868442042296497347060734559510750822400p 0.9
+ 35995412191401382172139950868442042296497347060734559510750822410p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644300p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644310p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644800p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644810p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289100p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289110p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289600p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289610p -0.3
+ 287963297531211057377119606947536338371978776485876476086006578700p -0.3
+ 287963297531211057377119606947536338371978776485876476086006578710p 0.9
+ 287963297531211057377119606947536338371978776485876476086006579200p 0.9
+ 287963297531211057377119606947536338371978776485876476086006579210p -0.3
+ 575926595062422114754239213895072676743957552971752952172013157900p -0.3
+ 575926595062422114754239213895072676743957552971752952172013157910p 0.9
+ 575926595062422114754239213895072676743957552971752952172013158400p 0.9
+ 575926595062422114754239213895072676743957552971752952172013158410p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316300p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316310p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316800p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316810p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633100p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633110p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633600p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633610p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105266700p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105266710p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105267200p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105267210p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210533900p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210533910p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210534400p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210534410p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068300p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068310p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068800p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068810p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137100p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137110p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137600p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137610p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684274700p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684274710p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684275200p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684275210p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368549900p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368549910p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368550400p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368550410p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100300p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100310p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100800p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100810p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201100p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201110p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201600p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201610p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948402700p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948402710p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948403200p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948403210p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896805900p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896805910p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896806400p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896806410p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612300p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612310p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612800p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612810p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225100p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225110p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225600p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225610p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174450700p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174450710p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174451200p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174451210p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348901900p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348901910p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348902400p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348902410p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804300p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804310p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804800p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804810p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609100p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609110p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609600p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609610p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791218700p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791218710p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791219200p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791219210p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582437900p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582437910p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582438400p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582438410p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876300p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876310p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876800p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876810p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753100p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753110p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753600p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753610p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659506700p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659506710p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659507200p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659507210p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319013900p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319013910p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319014400p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319014410p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028300p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028310p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028800p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028810p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057100p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057110p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057600p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057610p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552114700p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552114710p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552115200p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552115210p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104229900p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104229910p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104230400p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104230410p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460300p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460310p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460800p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460810p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921100p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921110p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921600p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921610p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833842700p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833842710p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833843200p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833843210p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667685900p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667685910p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667686400p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667686410p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372300p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372310p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372800p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372810p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745100p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745110p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745600p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745610p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341490700p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341490710p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341491200p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341491210p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682981900p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682981910p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682982400p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682982410p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964300p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964310p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964800p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964810p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929100p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929110p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929600p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929610p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463858700p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463858710p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463859200p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463859210p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927717900p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927717910p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927718400p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927718410p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436300p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436310p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436800p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436810p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873100p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873110p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873600p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873610p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746700p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746710p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747200p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747210p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493900p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493910p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494400p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494410p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988300p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988310p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988800p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988810p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977100p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977110p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977600p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977610p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954700p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954710p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955200p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955210p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909900p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909910p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910400p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910410p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820300p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820310p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820800p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820810p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641100p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641110p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641600p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641610p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282700p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282710p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283200p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283210p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565900p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565910p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566400p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566410p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132300p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132310p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132800p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132810p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265100p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265110p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265600p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265610p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530700p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530710p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531200p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531210p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061900p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061910p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062400p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062410p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124300p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124310p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124800p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124810p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249100p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249110p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249600p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249610p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498700p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498710p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499200p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499210p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997900p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997910p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998400p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998410p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996300p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996310p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996800p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996810p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993100p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993110p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993600p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993610p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986700p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986710p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987200p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987210p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973900p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973910p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974400p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974410p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948300p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948310p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948800p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948810p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897100p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897110p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897600p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897610p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794700p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794710p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795200p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795210p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589900p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589910p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590400p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590410p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180300p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180310p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180800p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180810p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361100p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361110p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361600p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361610p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722700p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722710p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723200p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723210p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445900p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445910p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446400p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446410p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892300p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892310p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892800p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892810p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785100p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785110p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785600p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785610p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570700p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570710p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571200p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571210p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141900p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141910p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142400p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142410p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284300p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284310p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284800p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284810p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569100p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569110p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569600p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569610p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138700p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138710p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139200p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139210p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277900p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277910p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278400p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278410p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556300p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556310p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556800p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556810p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113100p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113110p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113600p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113610p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226700p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226710p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227200p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227210p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453900p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453910p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454400p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454410p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908300p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908310p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908800p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908810p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817100p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817110p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817600p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817610p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634700p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634710p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635200p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635210p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269900p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269910p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270400p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270410p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540300p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540310p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540800p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540810p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081100p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081110p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081600p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081610p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162700p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162710p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163200p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163210p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325900p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325910p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326400p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326410p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652300p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652310p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652800p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652810p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305100p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305110p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305600p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305610p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610700p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610710p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611200p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611210p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221900p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221910p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222400p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222410p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444300p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444310p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444800p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444810p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889100p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889110p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889600p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889610p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778700p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778710p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779200p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779210p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557900p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557910p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558400p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558410p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116300p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116310p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116800p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116810p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233100p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233110p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233600p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233610p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466700p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466710p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467200p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467210p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933900p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933910p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934400p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934410p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868300p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868310p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868800p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868810p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737100p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737110p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737600p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737610p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474700p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474710p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475200p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475210p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949900p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949910p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950400p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950410p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900300p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900310p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900800p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900810p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801100p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801110p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801600p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801610p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602700p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602710p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603200p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603210p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205900p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205910p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206400p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206410p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412300p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412310p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412800p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412810p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825100p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825110p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825600p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825610p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650700p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650710p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651200p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651210p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301900p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301910p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302400p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302410p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604300p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604310p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604800p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604810p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209100p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209110p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209600p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209610p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418700p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418710p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419200p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419210p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837900p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837910p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838400p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838410p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676300p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676310p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676800p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676810p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353100p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353110p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353600p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353610p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706700p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706710p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707200p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707210p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413900p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413910p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414400p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414410p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828300p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828310p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828800p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828810p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657100p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657110p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657600p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657610p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314700p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314710p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315200p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315210p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629900p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629910p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630400p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630410p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260300p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260310p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260800p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260810p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521100p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521110p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521600p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521610p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042700p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042710p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043200p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043210p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085900p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085910p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086400p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086410p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172300p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172310p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172800p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172810p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345100p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345110p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345600p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345610p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690700p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690710p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691200p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691210p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381900p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381910p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382400p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382410p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764300p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764310p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764800p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764810p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529100p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529110p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529600p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529610p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058700p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058710p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059200p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059210p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117900p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117910p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118400p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118410p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236300p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236310p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236800p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236810p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473100p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473110p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473600p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473610p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946700p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946710p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947200p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947210p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893900p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893910p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894400p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894410p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788300p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788310p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788800p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788810p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577100p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577110p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577600p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577610p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154700p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154710p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155200p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155210p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309900p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309910p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310400p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310410p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620300p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620310p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620800p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620810p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241100p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241110p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241600p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241610p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482700p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482710p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483200p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483210p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965900p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965910p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966400p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966410p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932300p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932310p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932800p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932810p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865100p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865110p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865600p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865610p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730700p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730710p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731200p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731210p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461900p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461910p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462400p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462410p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924300p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924310p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924800p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924810p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849100p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849110p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849600p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849610p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698700p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698710p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699200p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699210p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397900p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397910p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398400p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398410p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796300p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796310p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796800p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796810p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593100p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593110p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593600p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593610p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186700p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186710p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187200p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187210p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373900p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373910p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374400p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374410p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748300p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748310p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748800p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748810p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497100p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497110p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497600p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497610p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994700p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994710p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995200p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995210p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989900p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989910p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990400p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990410p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980300p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980310p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980800p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980810p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961100p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961110p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961600p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961610p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922700p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922710p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923200p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923210p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845900p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845910p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846400p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846410p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692300p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692310p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692800p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692810p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385100p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385110p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385600p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385610p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770700p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770710p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771200p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771210p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541900p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541910p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542400p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542410p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084300p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084310p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084800p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084810p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169100p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169110p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169600p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169610p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338700p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338710p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339200p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339210p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677900p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677910p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678400p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678410p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356300p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356310p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356800p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356810p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713100p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713110p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713600p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713610p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426700p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426710p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427200p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427210p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853900p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853910p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854400p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854410p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708300p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708310p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708800p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708810p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417100p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417110p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417600p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417610p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834700p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834710p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835200p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835210p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669900p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669910p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670400p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670410p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340300p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340310p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340800p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340810p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681100p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681110p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681600p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681610p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362700p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362710p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363200p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363210p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725900p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725910p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726400p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726410p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452300p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452310p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452800p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452810p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905100p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905110p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905600p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905610p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810700p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810710p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811200p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811210p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621900p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621910p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622400p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622410p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244300p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244310p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244800p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244810p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489100p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489110p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489600p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489610p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978700p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978710p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979200p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979210p -0.3
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957900p -0.3
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957910p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958400p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958410p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916300p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916310p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916800p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916810p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833100p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833110p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833600p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833610p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666700p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666710p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667200p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667210p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333900p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333910p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334400p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334410p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668300p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668310p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668800p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668810p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337100p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337110p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337600p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337610p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674700p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674710p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675200p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675210p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349900p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349910p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350400p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350410p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700300p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700310p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700800p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700810p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401100p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401110p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401600p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401610p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802700p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802710p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803200p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803210p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605900p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605910p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606400p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606410p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212300p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212310p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212800p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212810p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425100p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425110p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425600p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425610p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850700p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850710p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851200p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851210p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701900p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701910p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702400p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702410p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404300p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404310p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404800p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404810p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809100p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809110p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809600p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809610p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618700p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618710p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619200p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619210p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237900p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237910p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238400p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238410p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476300p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476310p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476800p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476810p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953100p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953110p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953600p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953610p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906700p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906710p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907200p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907210p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813900p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813910p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814400p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814410p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628300p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628310p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628800p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628810p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257100p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257110p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257600p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257610p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514700p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514710p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515200p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515210p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029900p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029910p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030400p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030410p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060300p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060310p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060800p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060810p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121100p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121110p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121600p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121610p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242700p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242710p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243200p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243210p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485900p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485910p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486400p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486410p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972300p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972310p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972800p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972810p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945100p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945110p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945600p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945610p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890700p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890710p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891200p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891210p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781900p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781910p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782400p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782410p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564300p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564310p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564800p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564810p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129100p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129110p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129600p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129610p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258700p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258710p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259200p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259210p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517900p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517910p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518400p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518410p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036300p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036310p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036800p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036810p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073100p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073110p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073600p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073610p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146700p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146710p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147200p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147210p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293900p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293910p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294400p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294410p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588300p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588310p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588800p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588810p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177100p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177110p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177600p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177610p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354700p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354710p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355200p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355210p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709900p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709910p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710400p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710410p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420300p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420310p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420800p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420810p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841100p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841110p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841600p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841610p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682700p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682710p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683200p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683210p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365900p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365910p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366400p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366410p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732300p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732310p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732800p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732810p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465100p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465110p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465600p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465610p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930700p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930710p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931200p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931210p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861900p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861910p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862400p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862410p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724300p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724310p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724800p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724810p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449100p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449110p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449600p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449610p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898700p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898710p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899200p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899210p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797900p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797910p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798400p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798410p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596300p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596310p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596800p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596810p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193100p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193110p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193600p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193610p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386700p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386710p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387200p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387210p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773900p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773910p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774400p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774410p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548300p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548310p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548800p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548810p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097100p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097110p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097600p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097610p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194700p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194710p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195200p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195210p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389900p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389910p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390400p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390410p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780300p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780310p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780800p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780810p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561100p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561110p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561600p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561610p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122700p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122710p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123200p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123210p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245900p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245910p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246400p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246410p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492300p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492310p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492800p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492810p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985100p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985110p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985600p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985610p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970700p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970710p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971200p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971210p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941900p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941910p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942400p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942410p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884300p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884310p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884800p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884810p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769100p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769110p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769600p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769610p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538700p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538710p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539200p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539210p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077900p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077910p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078400p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078410p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156300p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156310p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156800p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156810p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313100p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313110p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313600p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313610p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626700p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626710p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627200p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627210p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253900p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253910p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254400p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254410p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508300p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508310p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508800p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508810p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017100p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017110p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017600p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017610p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034700p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034710p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035200p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035210p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069900p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069910p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070400p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070410p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140300p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140310p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140800p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140810p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281100p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281110p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281600p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281610p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562700p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562710p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563200p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563210p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125900p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125910p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126400p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126410p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252300p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252310p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252800p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252810p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505100p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505110p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505600p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505610p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010700p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010710p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011200p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011210p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021900p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021910p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022400p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022410p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044300p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044310p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044800p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044810p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089100p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089110p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089600p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089610p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178700p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178710p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179200p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179210p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357900p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357910p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358400p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358410p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716300p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716310p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716800p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716810p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433100p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433110p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433600p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433610p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866700p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866710p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867200p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867210p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733900p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733910p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734400p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734410p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468300p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468310p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468800p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468810p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937100p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937110p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937600p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937610p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874700p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874710p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875200p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875210p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749900p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749910p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750400p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750410p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500300p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500310p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500800p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500810p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001100p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001110p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001600p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001610p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002700p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002710p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003200p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003210p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005900p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005910p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006400p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006410p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012300p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012310p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012800p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012810p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025100p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025110p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025600p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025610p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050700p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050710p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051200p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051210p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101900p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101910p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102400p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102410p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204300p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204310p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204800p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204810p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409100p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409110p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409600p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409610p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818700p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818710p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819200p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819210p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637900p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637910p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638400p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638410p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276300p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276310p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276800p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276810p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553100p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553110p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553600p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553610p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106700p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106710p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107200p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107210p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213900p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213910p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214400p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214410p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428300p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428310p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428800p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428810p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857100p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857110p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857600p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857610p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714700p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714710p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715200p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715210p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429900p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429910p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430400p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430410p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860300p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860310p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860800p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860810p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721100p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721110p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721600p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721610p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442700p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442710p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443200p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443210p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885900p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885910p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886400p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886410p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772300p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772310p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772800p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772810p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545100p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545110p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545600p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545610p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090700p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090710p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091200p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091210p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181900p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181910p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182400p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182410p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364300p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364310p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364800p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364810p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729100p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729110p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729600p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729610p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458700p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458710p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459200p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459210p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917900p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917910p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918400p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918410p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836300p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836310p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836800p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836810p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673100p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673110p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673600p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673610p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346700p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346710p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347200p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347210p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693900p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693910p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694400p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694410p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388300p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388310p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388800p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388810p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777100p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777110p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777600p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777610p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554700p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554710p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555200p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555210p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109900p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109910p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110400p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110410p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220300p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220310p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220800p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220810p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441100p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441110p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441600p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441610p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882700p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882710p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883200p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883210p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765900p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765910p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766400p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766410p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532300p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532310p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532800p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532810p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065100p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065110p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065600p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065610p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130700p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130710p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131200p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131210p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261900p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261910p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262400p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262410p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524300p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524310p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524800p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524810p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049100p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049110p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049600p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049610p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098700p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098710p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099200p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099210p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197900p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197910p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198400p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198410p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396300p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396310p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396800p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396810p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793100p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793110p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793600p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793610p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586700p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586710p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587200p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587210p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173900p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173910p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174400p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174410p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348300p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348310p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348800p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348810p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697100p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697110p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697600p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697610p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394700p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394710p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395200p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395210p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789900p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789910p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790400p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790410p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580300p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580310p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580800p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580810p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161100p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161110p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161600p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161610p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322700p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322710p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323200p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323210p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645900p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645910p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646400p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646410p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292300p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292310p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292800p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292810p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585100p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585110p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585600p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585610p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170700p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170710p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171200p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171210p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341900p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341910p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342400p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342410p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684300p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684310p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684800p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684810p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369100p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369110p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369600p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369610p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738700p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738710p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739200p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739210p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477900p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477910p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478400p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478410p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956300p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956310p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956800p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956810p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913100p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913110p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913600p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913610p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826700p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826710p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827200p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827210p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653900p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653910p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654400p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654410p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308300p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308310p 0.9
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308800p 0.9
