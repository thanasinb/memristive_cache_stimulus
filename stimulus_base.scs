+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254400p 0.9
+ 58598126955498994114366994870468849015076825640146369157080099364003573108394944198846786341483367241352833675178687717002422007811298424259290658611632830959017167518570013201521501746434842182145061933649472910066463741306087010089186568455108937814061230737348277479392975641850289615515968497254410p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508300p -0.3
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508310p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508800p 0.9
+ 117196253910997988228733989740937698030153651280292738314160198728007146216789888397693572682966734482705667350357375434004844015622596848518581317223265661918034335037140026403043003492869684364290123867298945820132927482612174020178373136910217875628122461474696554958785951283700579231031936994508810p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017100p -0.3
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017110p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017600p 0.9
+ 234392507821995976457467979481875396060307302560585476628320397456014292433579776795387145365933468965411334700714750868009688031245193697037162634446531323836068670074280052806086006985739368728580247734597891640265854965224348040356746273820435751256244922949393109917571902567401158462063873989017610p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034700p -0.3
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978034710p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035200p 0.9
+ 468785015643991952914935958963750792120614605121170953256640794912028584867159553590774290731866937930822669401429501736019376062490387394074325268893062647672137340148560105612172013971478737457160495469195783280531709930448696080713492547640871502512489845898786219835143805134802316924127747978035210p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069900p -0.3
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956069910p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070400p 0.9
+ 937570031287983905829871917927501584241229210242341906513281589824057169734319107181548581463733875861645338802859003472038752124980774788148650537786125295344274680297120211224344027942957474914320990938391566561063419860897392161426985095281743005024979691797572439670287610269604633848255495956070410p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140300p -0.3
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140310p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140800p 0.9
+ 1875140062575967811659743835855003168482458420484683813026563179648114339468638214363097162927467751723290677605718006944077504249961549576297301075572250590688549360594240422448688055885914949828641981876783133122126839721794784322853970190563486010049959383595144879340575220539209267696510991912140810p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281100p -0.3
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281110p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281600p 0.9
+ 3750280125151935623319487671710006336964916840969367626053126359296228678937276428726194325854935503446581355211436013888155008499923099152594602151144501181377098721188480844897376111771829899657283963753566266244253679443589568645707940381126972020099918767190289758681150441078418535393021983824281610p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562700p -0.3
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648562710p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563200p 0.9
+ 7500560250303871246638975343420012673929833681938735252106252718592457357874552857452388651709871006893162710422872027776310016999846198305189204302289002362754197442376961689794752223543659799314567927507132532488507358887179137291415880762253944040199837534380579517362300882156837070786043967648563210p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125900p -0.3
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297125910p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126400p 0.9
+ 15001120500607742493277950686840025347859667363877470504212505437184914715749105714904777303419742013786325420845744055552620033999692396610378408604578004725508394884753923379589504447087319598629135855014265064977014717774358274582831761524507888080399675068761159034724601764313674141572087935297126410p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252300p -0.3
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252310p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252800p 0.9
+ 30002241001215484986555901373680050695719334727754941008425010874369829431498211429809554606839484027572650841691488111105240067999384793220756817209156009451016789769507846759179008894174639197258271710028530129954029435548716549165663523049015776160799350137522318069449203528627348283144175870594252810p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505100p -0.3
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505110p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505600p 0.9
+ 60004482002430969973111802747360101391438669455509882016850021748739658862996422859619109213678968055145301683382976222210480135998769586441513634418312018902033579539015693518358017788349278394516543420057060259908058871097433098331327046098031552321598700275044636138898407057254696566288351741188505610p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010700p -0.3
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377010710p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011200p 0.9
+ 120008964004861939946223605494720202782877338911019764033700043497479317725992845719238218427357936110290603366765952444420960271997539172883027268836624037804067159078031387036716035576698556789033086840114120519816117742194866196662654092196063104643197400550089272277796814114509393132576703482377011210p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021900p -0.3
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754021910p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022400p 0.9
+ 240017928009723879892447210989440405565754677822039528067400086994958635451985691438476436854715872220581206733531904888841920543995078345766054537673248075608134318156062774073432071153397113578066173680228241039632235484389732393325308184392126209286394801100178544555593628229018786265153406964754022410p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044300p -0.3
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044310p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044800p 0.9
+ 480035856019447759784894421978880811131509355644079056134800173989917270903971382876952873709431744441162413467063809777683841087990156691532109075346496151216268636312125548146864142306794227156132347360456482079264470968779464786650616368784252418572789602200357089111187256458037572530306813929508044810p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089100p -0.3
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089110p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089600p 0.9
+ 960071712038895519569788843957761622263018711288158112269600347979834541807942765753905747418863488882324826934127619555367682175980313383064218150692992302432537272624251096293728284613588454312264694720912964158528941937558929573301232737568504837145579204400714178222374512916075145060613627859016089610p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178700p -0.3
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032178710p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179200p 0.9
+ 1920143424077791039139577687915523244526037422576316224539200695959669083615885531507811494837726977764649653868255239110735364351960626766128436301385984604865074545248502192587456569227176908624529389441825928317057883875117859146602465475137009674291158408801428356444749025832150290121227255718032179210p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357900p -0.3
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064357910p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358400p 0.9
+ 3840286848155582078279155375831046489052074845152632449078401391919338167231771063015622989675453955529299307736510478221470728703921253532256872602771969209730149090497004385174913138454353817249058778883651856634115767750235718293204930950274019348582316817602856712889498051664300580242454511436064358410p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716300p -0.3
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716310p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716800p 0.9
+ 7680573696311164156558310751662092978104149690305264898156802783838676334463542126031245979350907911058598615473020956442941457407842507064513745205543938419460298180994008770349826276908707634498117557767303713268231535500471436586409861900548038697164633635205713425778996103328601160484909022872128716810p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433100p -0.3
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433110p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433600p 0.9
+ 15361147392622328313116621503324185956208299380610529796313605567677352668927084252062491958701815822117197230946041912885882914815685014129027490411087876838920596361988017540699652553817415268996235115534607426536463071000942873172819723801096077394329267270411426851557992206657202320969818045744257433610p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866700p -0.3
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514866710p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867200p 0.9
+ 30722294785244656626233243006648371912416598761221059592627211135354705337854168504124983917403631644234394461892083825771765829631370028258054980822175753677841192723976035081399305107634830537992470231069214853072926142001885746345639447602192154788658534540822853703115984413314404641939636091488514867210p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733900p -0.3
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029733910p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734400p 0.9
+ 61444589570489313252466486013296743824833197522442119185254422270709410675708337008249967834807263288468788923784167651543531659262740056516109961644351507355682385447952070162798610215269661075984940462138429706145852284003771492691278895204384309577317069081645707406231968826628809283879272182977029734410p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468300p -0.3
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468310p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468800p 0.9
+ 122889179140978626504932972026593487649666395044884238370508844541418821351416674016499935669614526576937577847568335303087063318525480113032219923288703014711364770895904140325597220430539322151969880924276859412291704568007542985382557790408768619154634138163291414812463937653257618567758544365954059468810p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937100p -0.3
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937110p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937600p 0.9
+ 245778358281957253009865944053186975299332790089768476741017689082837642702833348032999871339229053153875155695136670606174126637050960226064439846577406029422729541791808280651194440861078644303939761848553718824583409136015085970765115580817537238309268276326582829624927875306515237135517088731908118937610p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874700p -0.3
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237874710p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875200p 0.9
+ 491556716563914506019731888106373950598665580179536953482035378165675285405666696065999742678458106307750311390273341212348253274101920452128879693154812058845459083583616561302388881722157288607879523697107437649166818272030171941530231161635074476618536552653165659249855750613030474271034177463816237875210p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749900p -0.3
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475749910p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750400p 0.9
+ 983113433127829012039463776212747901197331160359073906964070756331350570811333392131999485356916212615500622780546682424696506548203840904257759386309624117690918167167233122604777763444314577215759047394214875298333636544060343883060462323270148953237073105306331318499711501226060948542068354927632475750410p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500300p -0.3
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500310p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500800p 0.9
+ 1966226866255658024078927552425495802394662320718147813928141512662701141622666784263998970713832425231001245561093364849393013096407681808515518772619248235381836334334466245209555526888629154431518094788429750596667273088120687766120924646540297906474146210612662636999423002452121897084136709855264951500810p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001100p -0.3
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001110p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001600p 0.9
+ 3932453732511316048157855104850991604789324641436295627856283025325402283245333568527997941427664850462002491122186729698786026192815363617031037545238496470763672668668932490419111053777258308863036189576859501193334546176241375532241849293080595812948292421225325273998846004904243794168273419710529903001610p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002700p -0.3
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806002710p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003200p 0.9
+ 7864907465022632096315710209701983209578649282872591255712566050650804566490667137055995882855329700924004982244373459397572052385630727234062075090476992941527345337337864980838222107554516617726072379153719002386669092352482751064483698586161191625896584842450650547997692009808487588336546839421059806003210p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005900p -0.3
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612005910p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006400p 0.9
+ 15729814930045264192631420419403966419157298565745182511425132101301609132981334274111991765710659401848009964488746918795144104771261454468124150180953985883054690674675729961676444215109033235452144758307438004773338184704965502128967397172322383251793169684901301095995384019616975176673093678842119612006410p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012300p -0.3
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012310p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012800p 0.9
+ 31459629860090528385262840838807932838314597131490365022850264202603218265962668548223983531421318803696019928977493837590288209542522908936248300361907971766109381349351459923352888430218066470904289516614876009546676369409931004257934794344644766503586339369802602191990768039233950353346187357684239224012810p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025100p -0.3
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025110p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025600p 0.9
+ 62919259720181056770525681677615865676629194262980730045700528405206436531925337096447967062842637607392039857954987675180576419085045817872496600723815943532218762698702919846705776860436132941808579033229752019093352738819862008515869588689289533007172678739605204383981536078467900706692374715368478448025610p -0.3
+ \]
