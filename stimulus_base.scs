Vdd    (vdd! gnd!)   vsource dc=0.9
V_read (V_Read gnd!) vsource dc=0.2
V_body (Vbody gnd!)  vsource dc=-0.3
V_ref  (Vref gnd!)   vsource dc=0.14
Vpp    (Vp gnd!)     vsource dc=0.9
Vnn    (Vn gnd!)     vsource dc=-0.3
Vhh    (Vh gnd!)     vsource dc=0.0
V_RW   (RW gnd!)     vsource type=pwl wave=\[
+ 0    -0.3
+ 200p -0.3
+ 210p 0.9
+ 700p 0.9
+ 710p -0.3
+ 900p -0.3
+ 910p 0.9
+ 1400p 0.9
+ 1410p -0.3
+ 2300p -0.3
+ 2310p 0.9
+ 2800p 0.9
+ 2810p -0.3
+ 5100p -0.3
+ 5110p 0.9
+ 5600p 0.9
+ 5610p -0.3
+ 10700p -0.3
+ 10710p 0.9
+ 11200p 0.9
+ 11210p -0.3
+ 21900p -0.3
+ 21910p 0.9
+ 22400p 0.9
+ 22410p -0.3
+ 44300p -0.3
+ 44310p 0.9
+ 44800p 0.9
+ 44810p -0.3
+ 89100p -0.3
+ 89110p 0.9
+ 89600p 0.9
+ 89610p -0.3
+ 178700p -0.3
+ 178710p 0.9
+ 179200p 0.9
+ 179210p -0.3
+ 357900p -0.3
+ 357910p 0.9
+ 358400p 0.9
+ 358410p -0.3
+ 716300p -0.3
+ 716310p 0.9
+ 716800p 0.9
+ 716810p -0.3
+ 1433100p -0.3
+ 1433110p 0.9
+ 1433600p 0.9
+ 1433610p -0.3
+ 2866700p -0.3
+ 2866710p 0.9
+ 2867200p 0.9
+ 2867210p -0.3
+ 5733900p -0.3
+ 5733910p 0.9
+ 5734400p 0.9
+ 5734410p -0.3
+ 11468300p -0.3
+ 11468310p 0.9
+ 11468800p 0.9
+ 11468810p -0.3
+ 22937100p -0.3
+ 22937110p 0.9
+ 22937600p 0.9
+ 22937610p -0.3
+ 45874700p -0.3
+ 45874710p 0.9
+ 45875200p 0.9
+ 45875210p -0.3
+ 91749900p -0.3
+ 91749910p 0.9
+ 91750400p 0.9
+ 91750410p -0.3
+ 183500300p -0.3
+ 183500310p 0.9
+ 183500800p 0.9
+ 183500810p -0.3
+ 367001100p -0.3
+ 367001110p 0.9
+ 367001600p 0.9
+ 367001610p -0.3
+ 734002700p -0.3
+ 734002710p 0.9
+ 734003200p 0.9
+ 734003210p -0.3
+ 1468005900p -0.3
+ 1468005910p 0.9
+ 1468006400p 0.9
+ 1468006410p -0.3
+ 2936012300p -0.3
+ 2936012310p 0.9
+ 2936012800p 0.9
+ 2936012810p -0.3
+ 5872025100p -0.3
+ 5872025110p 0.9
+ 5872025600p 0.9
+ 5872025610p -0.3
+ 11744050700p -0.3
+ 11744050710p 0.9
+ 11744051200p 0.9
+ 11744051210p -0.3
+ 23488101900p -0.3
+ 23488101910p 0.9
+ 23488102400p 0.9
+ 23488102410p -0.3
+ 46976204300p -0.3
+ 46976204310p 0.9
+ 46976204800p 0.9
+ 46976204810p -0.3
+ 93952409100p -0.3
+ 93952409110p 0.9
+ 93952409600p 0.9
+ 93952409610p -0.3
+ 187904818700p -0.3
+ 187904818710p 0.9
+ 187904819200p 0.9
+ 187904819210p -0.3
+ 375809637900p -0.3
+ 375809637910p 0.9
+ 375809638400p 0.9
+ 375809638410p -0.3
+ 751619276300p -0.3
+ 751619276310p 0.9
+ 751619276800p 0.9
+ 751619276810p -0.3
+ 1503238553100p -0.3
+ 1503238553110p 0.9
+ 1503238553600p 0.9
+ 1503238553610p -0.3
+ 3006477106700p -0.3
+ 3006477106710p 0.9
+ 3006477107200p 0.9
+ 3006477107210p -0.3
+ 6012954213900p -0.3
+ 6012954213910p 0.9
+ 6012954214400p 0.9
+ 6012954214410p -0.3
+ 12025908428300p -0.3
+ 12025908428310p 0.9
+ 12025908428800p 0.9
+ 12025908428810p -0.3
+ 24051816857100p -0.3
+ 24051816857110p 0.9
+ 24051816857600p 0.9
+ 24051816857610p -0.3
+ 48103633714700p -0.3
+ 48103633714710p 0.9
+ 48103633715200p 0.9
+ 48103633715210p -0.3
+ 96207267429900p -0.3
+ 96207267429910p 0.9
+ 96207267430400p 0.9
+ 96207267430410p -0.3
+ 192414534860300p -0.3
+ 192414534860310p 0.9
+ 192414534860800p 0.9
+ 192414534860810p -0.3
+ 384829069721100p -0.3
+ 384829069721110p 0.9
+ 384829069721600p 0.9
+ 384829069721610p -0.3
+ 769658139442700p -0.3
+ 769658139442710p 0.9
+ 769658139443200p 0.9
+ 769658139443210p -0.3
+ 1539316278885900p -0.3
+ 1539316278885910p 0.9
+ 1539316278886400p 0.9
+ 1539316278886410p -0.3
+ 3078632557772300p -0.3
+ 3078632557772310p 0.9
+ 3078632557772800p 0.9
+ 3078632557772810p -0.3
+ 6157265115545100p -0.3
+ 6157265115545110p 0.9
+ 6157265115545600p 0.9
+ 6157265115545610p -0.3
+ 12314530231090700p -0.3
+ 12314530231090710p 0.9
+ 12314530231091200p 0.9
+ 12314530231091210p -0.3
+ 24629060462181900p -0.3
+ 24629060462181910p 0.9
+ 24629060462182400p 0.9
+ 24629060462182410p -0.3
+ 49258120924364300p -0.3
+ 49258120924364310p 0.9
+ 49258120924364800p 0.9
+ 49258120924364810p -0.3
+ 98516241848729100p -0.3
+ 98516241848729110p 0.9
+ 98516241848729600p 0.9
+ 98516241848729610p -0.3
+ 197032483697458700p -0.3
+ 197032483697458710p 0.9
+ 197032483697459200p 0.9
+ 197032483697459210p -0.3
+ 394064967394917900p -0.3
+ 394064967394917910p 0.9
+ 394064967394918400p 0.9
+ 394064967394918410p -0.3
+ 788129934789836300p -0.3
+ 788129934789836310p 0.9
+ 788129934789836800p 0.9
+ 788129934789836810p -0.3
+ 1576259869579673100p -0.3
+ 1576259869579673110p 0.9
+ 1576259869579673600p 0.9
+ 1576259869579673610p -0.3
+ 3152519739159346700p -0.3
+ 3152519739159346710p 0.9
+ 3152519739159347200p 0.9
+ 3152519739159347210p -0.3
+ 6305039478318693900p -0.3
+ 6305039478318693910p 0.9
+ 6305039478318694400p 0.9
+ 6305039478318694410p -0.3
+ 12610078956637388300p -0.3
+ 12610078956637388310p 0.9
+ 12610078956637388800p 0.9
+ 12610078956637388810p -0.3
+ 25220157913274777100p -0.3
+ 25220157913274777110p 0.9
+ 25220157913274777600p 0.9
+ 25220157913274777610p -0.3
+ 50440315826549554700p -0.3
+ 50440315826549554710p 0.9
+ 50440315826549555200p 0.9
+ 50440315826549555210p -0.3
+ 100880631653099109900p -0.3
+ 100880631653099109910p 0.9
+ 100880631653099110400p 0.9
+ 100880631653099110410p -0.3
+ 201761263306198220300p -0.3
+ 201761263306198220310p 0.9
+ 201761263306198220800p 0.9
+ 201761263306198220810p -0.3
+ 403522526612396441100p -0.3
+ 403522526612396441110p 0.9
+ 403522526612396441600p 0.9
+ 403522526612396441610p -0.3
+ 807045053224792882700p -0.3
+ 807045053224792882710p 0.9
+ 807045053224792883200p 0.9
+ 807045053224792883210p -0.3
+ 1614090106449585765900p -0.3
+ 1614090106449585765910p 0.9
+ 1614090106449585766400p 0.9
+ 1614090106449585766410p -0.3
+ 3228180212899171532300p -0.3
+ 3228180212899171532310p 0.9
+ 3228180212899171532800p 0.9
+ 3228180212899171532810p -0.3
+ 6456360425798343065100p -0.3
+ 6456360425798343065110p 0.9
+ 6456360425798343065600p 0.9
+ 6456360425798343065610p -0.3
+ 12912720851596686130700p -0.3
+ 12912720851596686130710p 0.9
+ 12912720851596686131200p 0.9
+ 12912720851596686131210p -0.3
+ 25825441703193372261900p -0.3
+ 25825441703193372261910p 0.9
+ 25825441703193372262400p 0.9
+ 25825441703193372262410p -0.3
+ 51650883406386744524300p -0.3
+ 51650883406386744524310p 0.9
+ 51650883406386744524800p 0.9
+ 51650883406386744524810p -0.3
+ 103301766812773489049100p -0.3
+ 103301766812773489049110p 0.9
+ 103301766812773489049600p 0.9
+ 103301766812773489049610p -0.3
+ 206603533625546978098700p -0.3
+ 206603533625546978098710p 0.9
+ 206603533625546978099200p 0.9
+ 206603533625546978099210p -0.3
+ 413207067251093956197900p -0.3
+ 413207067251093956197910p 0.9
+ 413207067251093956198400p 0.9
+ 413207067251093956198410p -0.3
+ 826414134502187912396300p -0.3
+ 826414134502187912396310p 0.9
+ 826414134502187912396800p 0.9
+ 826414134502187912396810p -0.3
+ 1652828269004375824793100p -0.3
+ 1652828269004375824793110p 0.9
+ 1652828269004375824793600p 0.9
+ 1652828269004375824793610p -0.3
+ 3305656538008751649586700p -0.3
+ 3305656538008751649586710p 0.9
+ 3305656538008751649587200p 0.9
+ 3305656538008751649587210p -0.3
+ 6611313076017503299173900p -0.3
+ 6611313076017503299173910p 0.9
+ 6611313076017503299174400p 0.9
+ 6611313076017503299174410p -0.3
+ 13222626152035006598348300p -0.3
+ 13222626152035006598348310p 0.9
+ 13222626152035006598348800p 0.9
+ 13222626152035006598348810p -0.3
+ 26445252304070013196697100p -0.3
+ 26445252304070013196697110p 0.9
+ 26445252304070013196697600p 0.9
+ 26445252304070013196697610p -0.3
+ 52890504608140026393394700p -0.3
+ 52890504608140026393394710p 0.9
+ 52890504608140026393395200p 0.9
+ 52890504608140026393395210p -0.3
+ 105781009216280052786789900p -0.3
+ 105781009216280052786789910p 0.9
+ 105781009216280052786790400p 0.9
+ 105781009216280052786790410p -0.3
+ 211562018432560105573580300p -0.3
+ 211562018432560105573580310p 0.9
+ 211562018432560105573580800p 0.9
+ 211562018432560105573580810p -0.3
+ 423124036865120211147161100p -0.3
+ 423124036865120211147161110p 0.9
+ 423124036865120211147161600p 0.9
+ 423124036865120211147161610p -0.3
+ 846248073730240422294322700p -0.3
+ 846248073730240422294322710p 0.9
+ 846248073730240422294323200p 0.9
+ 846248073730240422294323210p -0.3
+ 1692496147460480844588645900p -0.3
+ 1692496147460480844588645910p 0.9
+ 1692496147460480844588646400p 0.9
+ 1692496147460480844588646410p -0.3
+ 3384992294920961689177292300p -0.3
+ 3384992294920961689177292310p 0.9
+ 3384992294920961689177292800p 0.9
+ 3384992294920961689177292810p -0.3
+ 6769984589841923378354585100p -0.3
+ 6769984589841923378354585110p 0.9
+ 6769984589841923378354585600p 0.9
+ 6769984589841923378354585610p -0.3
+ 13539969179683846756709170700p -0.3
+ 13539969179683846756709170710p 0.9
+ 13539969179683846756709171200p 0.9
+ 13539969179683846756709171210p -0.3
+ 27079938359367693513418341900p -0.3
+ 27079938359367693513418341910p 0.9
+ 27079938359367693513418342400p 0.9
+ 27079938359367693513418342410p -0.3
+ 54159876718735387026836684300p -0.3
+ 54159876718735387026836684310p 0.9
+ 54159876718735387026836684800p 0.9
+ 54159876718735387026836684810p -0.3
+ 108319753437470774053673369100p -0.3
+ 108319753437470774053673369110p 0.9
+ 108319753437470774053673369600p 0.9
+ 108319753437470774053673369610p -0.3
+ 216639506874941548107346738700p -0.3
+ 216639506874941548107346738710p 0.9
+ 216639506874941548107346739200p 0.9
+ 216639506874941548107346739210p -0.3
+ 433279013749883096214693477900p -0.3
+ 433279013749883096214693477910p 0.9
+ 433279013749883096214693478400p 0.9
+ 433279013749883096214693478410p -0.3
+ 866558027499766192429386956300p -0.3
+ 866558027499766192429386956310p 0.9
+ 866558027499766192429386956800p 0.9
+ 866558027499766192429386956810p -0.3
+ 1733116054999532384858773913100p -0.3
+ 1733116054999532384858773913110p 0.9
+ 1733116054999532384858773913600p 0.9
+ 1733116054999532384858773913610p -0.3
+ 3466232109999064769717547826700p -0.3
+ 3466232109999064769717547826710p 0.9
+ 3466232109999064769717547827200p 0.9
+ 3466232109999064769717547827210p -0.3
+ 6932464219998129539435095653900p -0.3
+ 6932464219998129539435095653910p 0.9
+ 6932464219998129539435095654400p 0.9
+ 6932464219998129539435095654410p -0.3
+ 13864928439996259078870191308300p -0.3
+ 13864928439996259078870191308310p 0.9
+ 13864928439996259078870191308800p 0.9
+ 13864928439996259078870191308810p -0.3
+ 27729856879992518157740382617100p -0.3
+ 27729856879992518157740382617110p 0.9
+ 27729856879992518157740382617600p 0.9
+ 27729856879992518157740382617610p -0.3
+ 55459713759985036315480765234700p -0.3
+ 55459713759985036315480765234710p 0.9
+ 55459713759985036315480765235200p 0.9
+ 55459713759985036315480765235210p -0.3
+ 110919427519970072630961530469900p -0.3
+ 110919427519970072630961530469910p 0.9
+ 110919427519970072630961530470400p 0.9
+ 110919427519970072630961530470410p -0.3
+ 221838855039940145261923060940300p -0.3
+ 221838855039940145261923060940310p 0.9
+ 221838855039940145261923060940800p 0.9
+ 221838855039940145261923060940810p -0.3
+ 443677710079880290523846121881100p -0.3
+ 443677710079880290523846121881110p 0.9
+ 443677710079880290523846121881600p 0.9
+ 443677710079880290523846121881610p -0.3
+ 887355420159760581047692243762700p -0.3
+ 887355420159760581047692243762710p 0.9
+ 887355420159760581047692243763200p 0.9
+ 887355420159760581047692243763210p -0.3
+ 1774710840319521162095384487525900p -0.3
+ 1774710840319521162095384487525910p 0.9
+ 1774710840319521162095384487526400p 0.9
+ 1774710840319521162095384487526410p -0.3
+ 3549421680639042324190768975052300p -0.3
+ 3549421680639042324190768975052310p 0.9
+ 3549421680639042324190768975052800p 0.9
+ 3549421680639042324190768975052810p -0.3
+ 7098843361278084648381537950105100p -0.3
+ 7098843361278084648381537950105110p 0.9
+ 7098843361278084648381537950105600p 0.9
+ 7098843361278084648381537950105610p -0.3
+ 14197686722556169296763075900210700p -0.3
+ 14197686722556169296763075900210710p 0.9
+ 14197686722556169296763075900211200p 0.9
+ 14197686722556169296763075900211210p -0.3
+ 28395373445112338593526151800421900p -0.3
+ 28395373445112338593526151800421910p 0.9
+ 28395373445112338593526151800422400p 0.9
+ 28395373445112338593526151800422410p -0.3
+ 56790746890224677187052303600844300p -0.3
+ 56790746890224677187052303600844310p 0.9
+ 56790746890224677187052303600844800p 0.9
+ 56790746890224677187052303600844810p -0.3
+ 113581493780449354374104607201689100p -0.3
+ 113581493780449354374104607201689110p 0.9
+ 113581493780449354374104607201689600p 0.9
+ 113581493780449354374104607201689610p -0.3
+ 227162987560898708748209214403378700p -0.3
+ 227162987560898708748209214403378710p 0.9
+ 227162987560898708748209214403379200p 0.9
+ 227162987560898708748209214403379210p -0.3
+ 454325975121797417496418428806757900p -0.3
+ 454325975121797417496418428806757910p 0.9
+ 454325975121797417496418428806758400p 0.9
+ 454325975121797417496418428806758410p -0.3
+ 908651950243594834992836857613516300p -0.3
+ 908651950243594834992836857613516310p 0.9
+ 908651950243594834992836857613516800p 0.9
+ 908651950243594834992836857613516810p -0.3
+ 1817303900487189669985673715227033100p -0.3
+ 1817303900487189669985673715227033110p 0.9
+ 1817303900487189669985673715227033600p 0.9
+ 1817303900487189669985673715227033610p -0.3
+ 3634607800974379339971347430454066700p -0.3
+ 3634607800974379339971347430454066710p 0.9
+ 3634607800974379339971347430454067200p 0.9
+ 3634607800974379339971347430454067210p -0.3
+ 7269215601948758679942694860908133900p -0.3
+ 7269215601948758679942694860908133910p 0.9
+ 7269215601948758679942694860908134400p 0.9
+ 7269215601948758679942694860908134410p -0.3
+ 14538431203897517359885389721816268300p -0.3
+ 14538431203897517359885389721816268310p 0.9
+ 14538431203897517359885389721816268800p 0.9
+ 14538431203897517359885389721816268810p -0.3
+ 29076862407795034719770779443632537100p -0.3
+ 29076862407795034719770779443632537110p 0.9
+ 29076862407795034719770779443632537600p 0.9
+ 29076862407795034719770779443632537610p -0.3
+ 58153724815590069439541558887265074700p -0.3
+ 58153724815590069439541558887265074710p 0.9
+ 58153724815590069439541558887265075200p 0.9
+ 58153724815590069439541558887265075210p -0.3
+ 116307449631180138879083117774530149900p -0.3
+ 116307449631180138879083117774530149910p 0.9
+ 116307449631180138879083117774530150400p 0.9
+ 116307449631180138879083117774530150410p -0.3
+ 232614899262360277758166235549060300300p -0.3
+ 232614899262360277758166235549060300310p 0.9
+ 232614899262360277758166235549060300800p 0.9
+ 232614899262360277758166235549060300810p -0.3
+ 465229798524720555516332471098120601100p -0.3
+ 465229798524720555516332471098120601110p 0.9
+ 465229798524720555516332471098120601600p 0.9
+ 465229798524720555516332471098120601610p -0.3
+ 930459597049441111032664942196241202700p -0.3
+ 930459597049441111032664942196241202710p 0.9
+ 930459597049441111032664942196241203200p 0.9
+ 930459597049441111032664942196241203210p -0.3
+ 1860919194098882222065329884392482405900p -0.3
+ 1860919194098882222065329884392482405910p 0.9
+ 1860919194098882222065329884392482406400p 0.9
+ 1860919194098882222065329884392482406410p -0.3
+ 3721838388197764444130659768784964812300p -0.3
+ 3721838388197764444130659768784964812310p 0.9
+ 3721838388197764444130659768784964812800p 0.9
+ 3721838388197764444130659768784964812810p -0.3
+ 7443676776395528888261319537569929625100p -0.3
+ 7443676776395528888261319537569929625110p 0.9
+ 7443676776395528888261319537569929625600p 0.9
+ 7443676776395528888261319537569929625610p -0.3
+ 14887353552791057776522639075139859250700p -0.3
+ 14887353552791057776522639075139859250710p 0.9
+ 14887353552791057776522639075139859251200p 0.9
+ 14887353552791057776522639075139859251210p -0.3
+ 29774707105582115553045278150279718501900p -0.3
+ 29774707105582115553045278150279718501910p 0.9
+ 29774707105582115553045278150279718502400p 0.9
+ 29774707105582115553045278150279718502410p -0.3
+ 59549414211164231106090556300559437004300p -0.3
+ 59549414211164231106090556300559437004310p 0.9
+ 59549414211164231106090556300559437004800p 0.9
+ 59549414211164231106090556300559437004810p -0.3
+ 119098828422328462212181112601118874009100p -0.3
+ 119098828422328462212181112601118874009110p 0.9
+ 119098828422328462212181112601118874009600p 0.9
+ 119098828422328462212181112601118874009610p -0.3
+ 238197656844656924424362225202237748018700p -0.3
+ 238197656844656924424362225202237748018710p 0.9
+ 238197656844656924424362225202237748019200p 0.9
+ 238197656844656924424362225202237748019210p -0.3
+ 476395313689313848848724450404475496037900p -0.3
+ 476395313689313848848724450404475496037910p 0.9
+ 476395313689313848848724450404475496038400p 0.9
+ 476395313689313848848724450404475496038410p -0.3
+ 952790627378627697697448900808950992076300p -0.3
+ 952790627378627697697448900808950992076310p 0.9
+ 952790627378627697697448900808950992076800p 0.9
+ 952790627378627697697448900808950992076810p -0.3
+ 1905581254757255395394897801617901984153100p -0.3
+ 1905581254757255395394897801617901984153110p 0.9
+ 1905581254757255395394897801617901984153600p 0.9
+ 1905581254757255395394897801617901984153610p -0.3
+ 3811162509514510790789795603235803968306700p -0.3
+ 3811162509514510790789795603235803968306710p 0.9
+ 3811162509514510790789795603235803968307200p 0.9
+ 3811162509514510790789795603235803968307210p -0.3
+ 7622325019029021581579591206471607936613900p -0.3
+ 7622325019029021581579591206471607936613910p 0.9
+ 7622325019029021581579591206471607936614400p 0.9
+ 7622325019029021581579591206471607936614410p -0.3
+ 15244650038058043163159182412943215873228300p -0.3
+ 15244650038058043163159182412943215873228310p 0.9
+ 15244650038058043163159182412943215873228800p 0.9
+ 15244650038058043163159182412943215873228810p -0.3
+ 30489300076116086326318364825886431746457100p -0.3
+ 30489300076116086326318364825886431746457110p 0.9
+ 30489300076116086326318364825886431746457600p 0.9
+ 30489300076116086326318364825886431746457610p -0.3
+ 60978600152232172652636729651772863492914700p -0.3
+ 60978600152232172652636729651772863492914710p 0.9
+ 60978600152232172652636729651772863492915200p 0.9
+ 60978600152232172652636729651772863492915210p -0.3
+ 121957200304464345305273459303545726985829900p -0.3
+ 121957200304464345305273459303545726985829910p 0.9
+ 121957200304464345305273459303545726985830400p 0.9
+ 121957200304464345305273459303545726985830410p -0.3
+ 243914400608928690610546918607091453971660300p -0.3
+ 243914400608928690610546918607091453971660310p 0.9
+ 243914400608928690610546918607091453971660800p 0.9
+ 243914400608928690610546918607091453971660810p -0.3
+ 487828801217857381221093837214182907943321100p -0.3
+ 487828801217857381221093837214182907943321110p 0.9
+ 487828801217857381221093837214182907943321600p 0.9
+ 487828801217857381221093837214182907943321610p -0.3
+ 975657602435714762442187674428365815886642700p -0.3
+ 975657602435714762442187674428365815886642710p 0.9
+ 975657602435714762442187674428365815886643200p 0.9
+ 975657602435714762442187674428365815886643210p -0.3
+ 1951315204871429524884375348856731631773285900p -0.3
+ 1951315204871429524884375348856731631773285910p 0.9
+ 1951315204871429524884375348856731631773286400p 0.9
+ 1951315204871429524884375348856731631773286410p -0.3
+ 3902630409742859049768750697713463263546572300p -0.3
+ 3902630409742859049768750697713463263546572310p 0.9
+ 3902630409742859049768750697713463263546572800p 0.9
+ 3902630409742859049768750697713463263546572810p -0.3
+ 7805260819485718099537501395426926527093145100p -0.3
+ 7805260819485718099537501395426926527093145110p 0.9
+ 7805260819485718099537501395426926527093145600p 0.9
+ 7805260819485718099537501395426926527093145610p -0.3
+ 15610521638971436199075002790853853054186290700p -0.3
+ 15610521638971436199075002790853853054186290710p 0.9
+ 15610521638971436199075002790853853054186291200p 0.9
+ 15610521638971436199075002790853853054186291210p -0.3
+ 31221043277942872398150005581707706108372581900p -0.3
+ 31221043277942872398150005581707706108372581910p 0.9
+ 31221043277942872398150005581707706108372582400p 0.9
+ 31221043277942872398150005581707706108372582410p -0.3
+ 62442086555885744796300011163415412216745164300p -0.3
+ 62442086555885744796300011163415412216745164310p 0.9
+ 62442086555885744796300011163415412216745164800p 0.9
+ 62442086555885744796300011163415412216745164810p -0.3
+ 124884173111771489592600022326830824433490329100p -0.3
+ 124884173111771489592600022326830824433490329110p 0.9
+ 124884173111771489592600022326830824433490329600p 0.9
+ 124884173111771489592600022326830824433490329610p -0.3
+ 249768346223542979185200044653661648866980658700p -0.3
+ 249768346223542979185200044653661648866980658710p 0.9
+ 249768346223542979185200044653661648866980659200p 0.9
+ 249768346223542979185200044653661648866980659210p -0.3
+ 499536692447085958370400089307323297733961317900p -0.3
+ 499536692447085958370400089307323297733961317910p 0.9
+ 499536692447085958370400089307323297733961318400p 0.9
+ 499536692447085958370400089307323297733961318410p -0.3
+ 999073384894171916740800178614646595467922636300p -0.3
+ 999073384894171916740800178614646595467922636310p 0.9
+ 999073384894171916740800178614646595467922636800p 0.9
+ 999073384894171916740800178614646595467922636810p -0.3
+ 1998146769788343833481600357229293190935845273100p -0.3
+ 1998146769788343833481600357229293190935845273110p 0.9
+ 1998146769788343833481600357229293190935845273600p 0.9
+ 1998146769788343833481600357229293190935845273610p -0.3
+ 3996293539576687666963200714458586381871690546700p -0.3
+ 3996293539576687666963200714458586381871690546710p 0.9
+ 3996293539576687666963200714458586381871690547200p 0.9
+ 3996293539576687666963200714458586381871690547210p -0.3
+ 7992587079153375333926401428917172763743381093900p -0.3
+ 7992587079153375333926401428917172763743381093910p 0.9
+ 7992587079153375333926401428917172763743381094400p 0.9
+ 7992587079153375333926401428917172763743381094410p -0.3
+ 15985174158306750667852802857834345527486762188300p -0.3
+ 15985174158306750667852802857834345527486762188310p 0.9
+ 15985174158306750667852802857834345527486762188800p 0.9
+ 15985174158306750667852802857834345527486762188810p -0.3
+ 31970348316613501335705605715668691054973524377100p -0.3
+ 31970348316613501335705605715668691054973524377110p 0.9
+ 31970348316613501335705605715668691054973524377600p 0.9
+ 31970348316613501335705605715668691054973524377610p -0.3
+ 63940696633227002671411211431337382109947048754700p -0.3
+ 63940696633227002671411211431337382109947048754710p 0.9
+ 63940696633227002671411211431337382109947048755200p 0.9
+ 63940696633227002671411211431337382109947048755210p -0.3
+ 127881393266454005342822422862674764219894097509900p -0.3
+ 127881393266454005342822422862674764219894097509910p 0.9
+ 127881393266454005342822422862674764219894097510400p 0.9
+ 127881393266454005342822422862674764219894097510410p -0.3
+ 255762786532908010685644845725349528439788195020300p -0.3
+ 255762786532908010685644845725349528439788195020310p 0.9
+ 255762786532908010685644845725349528439788195020800p 0.9
+ 255762786532908010685644845725349528439788195020810p -0.3
+ 511525573065816021371289691450699056879576390041100p -0.3
+ 511525573065816021371289691450699056879576390041110p 0.9
+ 511525573065816021371289691450699056879576390041600p 0.9
+ 511525573065816021371289691450699056879576390041610p -0.3
+ 1023051146131632042742579382901398113759152780082700p -0.3
+ 1023051146131632042742579382901398113759152780082710p 0.9
+ 1023051146131632042742579382901398113759152780083200p 0.9
+ 1023051146131632042742579382901398113759152780083210p -0.3
+ 2046102292263264085485158765802796227518305560165900p -0.3
+ 2046102292263264085485158765802796227518305560165910p 0.9
+ 2046102292263264085485158765802796227518305560166400p 0.9
+ 2046102292263264085485158765802796227518305560166410p -0.3
+ 4092204584526528170970317531605592455036611120332300p -0.3
+ 4092204584526528170970317531605592455036611120332310p 0.9
+ 4092204584526528170970317531605592455036611120332800p 0.9
+ 4092204584526528170970317531605592455036611120332810p -0.3
+ 8184409169053056341940635063211184910073222240665100p -0.3
+ 8184409169053056341940635063211184910073222240665110p 0.9
+ 8184409169053056341940635063211184910073222240665600p 0.9
+ 8184409169053056341940635063211184910073222240665610p -0.3
+ 16368818338106112683881270126422369820146444481330700p -0.3
+ 16368818338106112683881270126422369820146444481330710p 0.9
+ 16368818338106112683881270126422369820146444481331200p 0.9
+ 16368818338106112683881270126422369820146444481331210p -0.3
+ 32737636676212225367762540252844739640292888962661900p -0.3
+ 32737636676212225367762540252844739640292888962661910p 0.9
+ 32737636676212225367762540252844739640292888962662400p 0.9
+ 32737636676212225367762540252844739640292888962662410p -0.3
+ 65475273352424450735525080505689479280585777925324300p -0.3
+ 65475273352424450735525080505689479280585777925324310p 0.9
+ 65475273352424450735525080505689479280585777925324800p 0.9
+ 65475273352424450735525080505689479280585777925324810p -0.3
+ 130950546704848901471050161011378958561171555850649100p -0.3
+ 130950546704848901471050161011378958561171555850649110p 0.9
+ 130950546704848901471050161011378958561171555850649600p 0.9
+ 130950546704848901471050161011378958561171555850649610p -0.3
+ 261901093409697802942100322022757917122343111701298700p -0.3
+ 261901093409697802942100322022757917122343111701298710p 0.9
+ 261901093409697802942100322022757917122343111701299200p 0.9
+ 261901093409697802942100322022757917122343111701299210p -0.3
+ 523802186819395605884200644045515834244686223402597900p -0.3
+ 523802186819395605884200644045515834244686223402597910p 0.9
+ 523802186819395605884200644045515834244686223402598400p 0.9
+ 523802186819395605884200644045515834244686223402598410p -0.3
+ 1047604373638791211768401288091031668489372446805196300p -0.3
+ 1047604373638791211768401288091031668489372446805196310p 0.9
+ 1047604373638791211768401288091031668489372446805196800p 0.9
+ 1047604373638791211768401288091031668489372446805196810p -0.3
+ 2095208747277582423536802576182063336978744893610393100p -0.3
+ 2095208747277582423536802576182063336978744893610393110p 0.9
+ 2095208747277582423536802576182063336978744893610393600p 0.9
+ 2095208747277582423536802576182063336978744893610393610p -0.3
+ 4190417494555164847073605152364126673957489787220786700p -0.3
+ 4190417494555164847073605152364126673957489787220786710p 0.9
+ 4190417494555164847073605152364126673957489787220787200p 0.9
+ 4190417494555164847073605152364126673957489787220787210p -0.3
+ 8380834989110329694147210304728253347914979574441573900p -0.3
+ 8380834989110329694147210304728253347914979574441573910p 0.9
+ 8380834989110329694147210304728253347914979574441574400p 0.9
+ 8380834989110329694147210304728253347914979574441574410p -0.3
+ 16761669978220659388294420609456506695829959148883148300p -0.3
+ 16761669978220659388294420609456506695829959148883148310p 0.9
+ 16761669978220659388294420609456506695829959148883148800p 0.9
+ 16761669978220659388294420609456506695829959148883148810p -0.3
+ 33523339956441318776588841218913013391659918297766297100p -0.3
+ 33523339956441318776588841218913013391659918297766297110p 0.9
+ 33523339956441318776588841218913013391659918297766297600p 0.9
+ 33523339956441318776588841218913013391659918297766297610p -0.3
+ 67046679912882637553177682437826026783319836595532594700p -0.3
+ 67046679912882637553177682437826026783319836595532594710p 0.9
+ 67046679912882637553177682437826026783319836595532595200p 0.9
+ 67046679912882637553177682437826026783319836595532595210p -0.3
+ 134093359825765275106355364875652053566639673191065189900p -0.3
+ 134093359825765275106355364875652053566639673191065189910p 0.9
+ 134093359825765275106355364875652053566639673191065190400p 0.9
+ 134093359825765275106355364875652053566639673191065190410p -0.3
+ 268186719651530550212710729751304107133279346382130380300p -0.3
+ 268186719651530550212710729751304107133279346382130380310p 0.9
+ 268186719651530550212710729751304107133279346382130380800p 0.9
+ 268186719651530550212710729751304107133279346382130380810p -0.3
+ 536373439303061100425421459502608214266558692764260761100p -0.3
+ 536373439303061100425421459502608214266558692764260761110p 0.9
+ 536373439303061100425421459502608214266558692764260761600p 0.9
+ 536373439303061100425421459502608214266558692764260761610p -0.3
+ 1072746878606122200850842919005216428533117385528521522700p -0.3
+ 1072746878606122200850842919005216428533117385528521522710p 0.9
+ 1072746878606122200850842919005216428533117385528521523200p 0.9
+ 1072746878606122200850842919005216428533117385528521523210p -0.3
+ 2145493757212244401701685838010432857066234771057043045900p -0.3
+ 2145493757212244401701685838010432857066234771057043045910p 0.9
+ 2145493757212244401701685838010432857066234771057043046400p 0.9
+ 2145493757212244401701685838010432857066234771057043046410p -0.3
+ 4290987514424488803403371676020865714132469542114086092300p -0.3
+ 4290987514424488803403371676020865714132469542114086092310p 0.9
+ 4290987514424488803403371676020865714132469542114086092800p 0.9
+ 4290987514424488803403371676020865714132469542114086092810p -0.3
+ 8581975028848977606806743352041731428264939084228172185100p -0.3
+ 8581975028848977606806743352041731428264939084228172185110p 0.9
+ 8581975028848977606806743352041731428264939084228172185600p 0.9
+ 8581975028848977606806743352041731428264939084228172185610p -0.3
+ 17163950057697955213613486704083462856529878168456344370700p -0.3
+ 17163950057697955213613486704083462856529878168456344370710p 0.9
+ 17163950057697955213613486704083462856529878168456344371200p 0.9
+ 17163950057697955213613486704083462856529878168456344371210p -0.3
+ 34327900115395910427226973408166925713059756336912688741900p -0.3
+ 34327900115395910427226973408166925713059756336912688741910p 0.9
+ 34327900115395910427226973408166925713059756336912688742400p 0.9
+ 34327900115395910427226973408166925713059756336912688742410p -0.3
+ 68655800230791820854453946816333851426119512673825377484300p -0.3
+ 68655800230791820854453946816333851426119512673825377484310p 0.9
+ 68655800230791820854453946816333851426119512673825377484800p 0.9
+ 68655800230791820854453946816333851426119512673825377484810p -0.3
+ 137311600461583641708907893632667702852239025347650754969100p -0.3
+ 137311600461583641708907893632667702852239025347650754969110p 0.9
+ 137311600461583641708907893632667702852239025347650754969600p 0.9
+ 137311600461583641708907893632667702852239025347650754969610p -0.3
+ 274623200923167283417815787265335405704478050695301509938700p -0.3
+ 274623200923167283417815787265335405704478050695301509938710p 0.9
+ 274623200923167283417815787265335405704478050695301509939200p 0.9
+ 274623200923167283417815787265335405704478050695301509939210p -0.3
+ 549246401846334566835631574530670811408956101390603019877900p -0.3
+ 549246401846334566835631574530670811408956101390603019877910p 0.9
+ 549246401846334566835631574530670811408956101390603019878400p 0.9
+ 549246401846334566835631574530670811408956101390603019878410p -0.3
+ 1098492803692669133671263149061341622817912202781206039756300p -0.3
+ 1098492803692669133671263149061341622817912202781206039756310p 0.9
+ 1098492803692669133671263149061341622817912202781206039756800p 0.9
+ 1098492803692669133671263149061341622817912202781206039756810p -0.3
+ 2196985607385338267342526298122683245635824405562412079513100p -0.3
+ 2196985607385338267342526298122683245635824405562412079513110p 0.9
+ 2196985607385338267342526298122683245635824405562412079513600p 0.9
+ 2196985607385338267342526298122683245635824405562412079513610p -0.3
+ 4393971214770676534685052596245366491271648811124824159026700p -0.3
+ 4393971214770676534685052596245366491271648811124824159026710p 0.9
+ 4393971214770676534685052596245366491271648811124824159027200p 0.9
+ 4393971214770676534685052596245366491271648811124824159027210p -0.3
+ 8787942429541353069370105192490732982543297622249648318053900p -0.3
+ 8787942429541353069370105192490732982543297622249648318053910p 0.9
+ 8787942429541353069370105192490732982543297622249648318054400p 0.9
+ 8787942429541353069370105192490732982543297622249648318054410p -0.3
+ 17575884859082706138740210384981465965086595244499296636108300p -0.3
+ 17575884859082706138740210384981465965086595244499296636108310p 0.9
+ 17575884859082706138740210384981465965086595244499296636108800p 0.9
+ 17575884859082706138740210384981465965086595244499296636108810p -0.3
+ 35151769718165412277480420769962931930173190488998593272217100p -0.3
+ 35151769718165412277480420769962931930173190488998593272217110p 0.9
+ 35151769718165412277480420769962931930173190488998593272217600p 0.9
+ 35151769718165412277480420769962931930173190488998593272217610p -0.3
+ 70303539436330824554960841539925863860346380977997186544434700p -0.3
+ 70303539436330824554960841539925863860346380977997186544434710p 0.9
+ 70303539436330824554960841539925863860346380977997186544435200p 0.9
+ 70303539436330824554960841539925863860346380977997186544435210p -0.3
+ 140607078872661649109921683079851727720692761955994373088869900p -0.3
+ 140607078872661649109921683079851727720692761955994373088869910p 0.9
+ 140607078872661649109921683079851727720692761955994373088870400p 0.9
+ 140607078872661649109921683079851727720692761955994373088870410p -0.3
+ 281214157745323298219843366159703455441385523911988746177740300p -0.3
+ 281214157745323298219843366159703455441385523911988746177740310p 0.9
+ 281214157745323298219843366159703455441385523911988746177740800p 0.9
+ 281214157745323298219843366159703455441385523911988746177740810p -0.3
+ 562428315490646596439686732319406910882771047823977492355481100p -0.3
+ 562428315490646596439686732319406910882771047823977492355481110p 0.9
+ 562428315490646596439686732319406910882771047823977492355481600p 0.9
+ 562428315490646596439686732319406910882771047823977492355481610p -0.3
+ 1124856630981293192879373464638813821765542095647954984710962700p -0.3
+ 1124856630981293192879373464638813821765542095647954984710962710p 0.9
+ 1124856630981293192879373464638813821765542095647954984710963200p 0.9
+ 1124856630981293192879373464638813821765542095647954984710963210p -0.3
+ 2249713261962586385758746929277627643531084191295909969421925900p -0.3
+ 2249713261962586385758746929277627643531084191295909969421925910p 0.9
+ 2249713261962586385758746929277627643531084191295909969421926400p 0.9
+ 2249713261962586385758746929277627643531084191295909969421926410p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852300p -0.3
+ 4499426523925172771517493858555255287062168382591819938843852310p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852800p 0.9
+ 4499426523925172771517493858555255287062168382591819938843852810p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705100p -0.3
+ 8998853047850345543034987717110510574124336765183639877687705110p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705600p 0.9
+ 8998853047850345543034987717110510574124336765183639877687705610p -0.3
+ 17997706095700691086069975434221021148248673530367279755375410700p -0.3
+ 17997706095700691086069975434221021148248673530367279755375410710p 0.9
+ 17997706095700691086069975434221021148248673530367279755375411200p 0.9
+ 17997706095700691086069975434221021148248673530367279755375411210p -0.3
+ 35995412191401382172139950868442042296497347060734559510750821900p -0.3
+ 35995412191401382172139950868442042296497347060734559510750821910p 0.9
+ 35995412191401382172139950868442042296497347060734559510750822400p 0.9
+ 35995412191401382172139950868442042296497347060734559510750822410p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644300p -0.3
+ 71990824382802764344279901736884084592994694121469119021501644310p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644800p 0.9
+ 71990824382802764344279901736884084592994694121469119021501644810p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289100p -0.3
+ 143981648765605528688559803473768169185989388242938238043003289110p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289600p 0.9
+ 143981648765605528688559803473768169185989388242938238043003289610p -0.3
+ 287963297531211057377119606947536338371978776485876476086006578700p -0.3
+ 287963297531211057377119606947536338371978776485876476086006578710p 0.9
+ 287963297531211057377119606947536338371978776485876476086006579200p 0.9
+ 287963297531211057377119606947536338371978776485876476086006579210p -0.3
+ 575926595062422114754239213895072676743957552971752952172013157900p -0.3
+ 575926595062422114754239213895072676743957552971752952172013157910p 0.9
+ 575926595062422114754239213895072676743957552971752952172013158400p 0.9
+ 575926595062422114754239213895072676743957552971752952172013158410p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316300p -0.3
+ 1151853190124844229508478427790145353487915105943505904344026316310p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316800p 0.9
+ 1151853190124844229508478427790145353487915105943505904344026316810p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633100p -0.3
+ 2303706380249688459016956855580290706975830211887011808688052633110p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633600p 0.9
+ 2303706380249688459016956855580290706975830211887011808688052633610p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105266700p -0.3
+ 4607412760499376918033913711160581413951660423774023617376105266710p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105267200p 0.9
+ 4607412760499376918033913711160581413951660423774023617376105267210p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210533900p -0.3
+ 9214825520998753836067827422321162827903320847548047234752210533910p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210534400p 0.9
+ 9214825520998753836067827422321162827903320847548047234752210534410p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068300p -0.3
+ 18429651041997507672135654844642325655806641695096094469504421068310p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068800p 0.9
+ 18429651041997507672135654844642325655806641695096094469504421068810p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137100p -0.3
+ 36859302083995015344271309689284651311613283390192188939008842137110p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137600p 0.9
+ 36859302083995015344271309689284651311613283390192188939008842137610p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684274700p -0.3
+ 73718604167990030688542619378569302623226566780384377878017684274710p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684275200p 0.9
+ 73718604167990030688542619378569302623226566780384377878017684275210p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368549900p -0.3
+ 147437208335980061377085238757138605246453133560768755756035368549910p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368550400p 0.9
+ 147437208335980061377085238757138605246453133560768755756035368550410p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100300p -0.3
+ 294874416671960122754170477514277210492906267121537511512070737100310p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100800p 0.9
+ 294874416671960122754170477514277210492906267121537511512070737100810p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201100p -0.3
+ 589748833343920245508340955028554420985812534243075023024141474201110p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201600p 0.9
+ 589748833343920245508340955028554420985812534243075023024141474201610p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948402700p -0.3
+ 1179497666687840491016681910057108841971625068486150046048282948402710p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948403200p 0.9
+ 1179497666687840491016681910057108841971625068486150046048282948403210p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896805900p -0.3
+ 2358995333375680982033363820114217683943250136972300092096565896805910p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896806400p 0.9
+ 2358995333375680982033363820114217683943250136972300092096565896806410p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612300p -0.3
+ 4717990666751361964066727640228435367886500273944600184193131793612310p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612800p 0.9
+ 4717990666751361964066727640228435367886500273944600184193131793612810p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225100p -0.3
+ 9435981333502723928133455280456870735773000547889200368386263587225110p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225600p 0.9
+ 9435981333502723928133455280456870735773000547889200368386263587225610p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174450700p -0.3
+ 18871962667005447856266910560913741471546001095778400736772527174450710p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174451200p 0.9
+ 18871962667005447856266910560913741471546001095778400736772527174451210p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348901900p -0.3
+ 37743925334010895712533821121827482943092002191556801473545054348901910p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348902400p 0.9
+ 37743925334010895712533821121827482943092002191556801473545054348902410p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804300p -0.3
+ 75487850668021791425067642243654965886184004383113602947090108697804310p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804800p 0.9
+ 75487850668021791425067642243654965886184004383113602947090108697804810p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609100p -0.3
+ 150975701336043582850135284487309931772368008766227205894180217395609110p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609600p 0.9
+ 150975701336043582850135284487309931772368008766227205894180217395609610p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791218700p -0.3
+ 301951402672087165700270568974619863544736017532454411788360434791218710p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791219200p 0.9
+ 301951402672087165700270568974619863544736017532454411788360434791219210p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582437900p -0.3
+ 603902805344174331400541137949239727089472035064908823576720869582437910p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582438400p 0.9
+ 603902805344174331400541137949239727089472035064908823576720869582438410p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876300p -0.3
+ 1207805610688348662801082275898479454178944070129817647153441739164876310p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876800p 0.9
+ 1207805610688348662801082275898479454178944070129817647153441739164876810p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753100p -0.3
+ 2415611221376697325602164551796958908357888140259635294306883478329753110p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753600p 0.9
+ 2415611221376697325602164551796958908357888140259635294306883478329753610p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659506700p -0.3
+ 4831222442753394651204329103593917816715776280519270588613766956659506710p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659507200p 0.9
+ 4831222442753394651204329103593917816715776280519270588613766956659507210p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319013900p -0.3
+ 9662444885506789302408658207187835633431552561038541177227533913319013910p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319014400p 0.9
+ 9662444885506789302408658207187835633431552561038541177227533913319014410p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028300p -0.3
+ 19324889771013578604817316414375671266863105122077082354455067826638028310p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028800p 0.9
+ 19324889771013578604817316414375671266863105122077082354455067826638028810p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057100p -0.3
+ 38649779542027157209634632828751342533726210244154164708910135653276057110p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057600p 0.9
+ 38649779542027157209634632828751342533726210244154164708910135653276057610p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552114700p -0.3
+ 77299559084054314419269265657502685067452420488308329417820271306552114710p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552115200p 0.9
+ 77299559084054314419269265657502685067452420488308329417820271306552115210p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104229900p -0.3
+ 154599118168108628838538531315005370134904840976616658835640542613104229910p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104230400p 0.9
+ 154599118168108628838538531315005370134904840976616658835640542613104230410p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460300p -0.3
+ 309198236336217257677077062630010740269809681953233317671281085226208460310p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460800p 0.9
+ 309198236336217257677077062630010740269809681953233317671281085226208460810p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921100p -0.3
+ 618396472672434515354154125260021480539619363906466635342562170452416921110p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921600p 0.9
+ 618396472672434515354154125260021480539619363906466635342562170452416921610p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833842700p -0.3
+ 1236792945344869030708308250520042961079238727812933270685124340904833842710p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833843200p 0.9
+ 1236792945344869030708308250520042961079238727812933270685124340904833843210p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667685900p -0.3
+ 2473585890689738061416616501040085922158477455625866541370248681809667685910p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667686400p 0.9
+ 2473585890689738061416616501040085922158477455625866541370248681809667686410p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372300p -0.3
+ 4947171781379476122833233002080171844316954911251733082740497363619335372310p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372800p 0.9
+ 4947171781379476122833233002080171844316954911251733082740497363619335372810p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745100p -0.3
+ 9894343562758952245666466004160343688633909822503466165480994727238670745110p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745600p 0.9
+ 9894343562758952245666466004160343688633909822503466165480994727238670745610p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341490700p -0.3
+ 19788687125517904491332932008320687377267819645006932330961989454477341490710p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341491200p 0.9
+ 19788687125517904491332932008320687377267819645006932330961989454477341491210p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682981900p -0.3
+ 39577374251035808982665864016641374754535639290013864661923978908954682981910p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682982400p 0.9
+ 39577374251035808982665864016641374754535639290013864661923978908954682982410p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964300p -0.3
+ 79154748502071617965331728033282749509071278580027729323847957817909365964310p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964800p 0.9
+ 79154748502071617965331728033282749509071278580027729323847957817909365964810p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929100p -0.3
+ 158309497004143235930663456066565499018142557160055458647695915635818731929110p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929600p 0.9
+ 158309497004143235930663456066565499018142557160055458647695915635818731929610p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463858700p -0.3
+ 316618994008286471861326912133130998036285114320110917295391831271637463858710p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463859200p 0.9
+ 316618994008286471861326912133130998036285114320110917295391831271637463859210p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927717900p -0.3
+ 633237988016572943722653824266261996072570228640221834590783662543274927717910p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927718400p 0.9
+ 633237988016572943722653824266261996072570228640221834590783662543274927718410p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436300p -0.3
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436310p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436800p 0.9
+ 1266475976033145887445307648532523992145140457280443669181567325086549855436810p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873100p -0.3
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873110p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873600p 0.9
+ 2532951952066291774890615297065047984290280914560887338363134650173099710873610p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746700p -0.3
+ 5065903904132583549781230594130095968580561829121774676726269300346199421746710p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747200p 0.9
+ 5065903904132583549781230594130095968580561829121774676726269300346199421747210p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493900p -0.3
+ 10131807808265167099562461188260191937161123658243549353452538600692398843493910p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494400p 0.9
+ 10131807808265167099562461188260191937161123658243549353452538600692398843494410p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988300p -0.3
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988310p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988800p 0.9
+ 20263615616530334199124922376520383874322247316487098706905077201384797686988810p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977100p -0.3
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977110p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977600p 0.9
+ 40527231233060668398249844753040767748644494632974197413810154402769595373977610p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954700p -0.3
+ 81054462466121336796499689506081535497288989265948394827620308805539190747954710p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955200p 0.9
+ 81054462466121336796499689506081535497288989265948394827620308805539190747955210p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909900p -0.3
+ 162108924932242673592999379012163070994577978531896789655240617611078381495909910p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910400p 0.9
+ 162108924932242673592999379012163070994577978531896789655240617611078381495910410p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820300p -0.3
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820310p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820800p 0.9
+ 324217849864485347185998758024326141989155957063793579310481235222156762991820810p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641100p -0.3
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641110p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641600p 0.9
+ 648435699728970694371997516048652283978311914127587158620962470444313525983641610p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282700p -0.3
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967282710p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283200p 0.9
+ 1296871399457941388743995032097304567956623828255174317241924940888627051967283210p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565900p -0.3
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934565910p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566400p 0.9
+ 2593742798915882777487990064194609135913247656510348634483849881777254103934566410p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132300p -0.3
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132310p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132800p 0.9
+ 5187485597831765554975980128389218271826495313020697268967699763554508207869132810p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265100p -0.3
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265110p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265600p 0.9
+ 10374971195663531109951960256778436543652990626041394537935399527109016415738265610p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530700p -0.3
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476530710p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531200p 0.9
+ 20749942391327062219903920513556873087305981252082789075870799054218032831476531210p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061900p -0.3
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953061910p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062400p 0.9
+ 41499884782654124439807841027113746174611962504165578151741598108436065662953062410p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124300p -0.3
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124310p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124800p 0.9
+ 82999769565308248879615682054227492349223925008331156303483196216872131325906124810p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249100p -0.3
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249110p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249600p 0.9
+ 165999539130616497759231364108454984698447850016662312606966392433744262651812249610p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498700p -0.3
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624498710p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499200p 0.9
+ 331999078261232995518462728216909969396895700033324625213932784867488525303624499210p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997900p -0.3
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248997910p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998400p 0.9
+ 663998156522465991036925456433819938793791400066649250427865569734977050607248998410p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996300p -0.3
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996310p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996800p 0.9
+ 1327996313044931982073850912867639877587582800133298500855731139469954101214497996810p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993100p -0.3
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993110p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993600p 0.9
+ 2655992626089863964147701825735279755175165600266597001711462278939908202428995993610p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986700p -0.3
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991986710p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987200p 0.9
+ 5311985252179727928295403651470559510350331200533194003422924557879816404857991987210p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973900p -0.3
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983973910p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974400p 0.9
+ 10623970504359455856590807302941119020700662401066388006845849115759632809715983974410p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948300p -0.3
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948310p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948800p 0.9
+ 21247941008718911713181614605882238041401324802132776013691698231519265619431967948810p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897100p -0.3
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897110p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897600p 0.9
+ 42495882017437823426363229211764476082802649604265552027383396463038531238863935897610p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794700p -0.3
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871794710p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795200p 0.9
+ 84991764034875646852726458423528952165605299208531104054766792926077062477727871795210p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589900p -0.3
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743589910p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590400p 0.9
+ 169983528069751293705452916847057904331210598417062208109533585852154124955455743590410p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180300p -0.3
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180310p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180800p 0.9
+ 339967056139502587410905833694115808662421196834124416219067171704308249910911487180810p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361100p -0.3
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361110p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361600p 0.9
+ 679934112279005174821811667388231617324842393668248832438134343408616499821822974361610p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722700p -0.3
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948722710p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723200p 0.9
+ 1359868224558010349643623334776463234649684787336497664876268686817232999643645948723210p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445900p -0.3
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897445910p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446400p 0.9
+ 2719736449116020699287246669552926469299369574672995329752537373634465999287291897446410p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892300p -0.3
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892310p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892800p 0.9
+ 5439472898232041398574493339105852938598739149345990659505074747268931998574583794892810p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785100p -0.3
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785110p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785600p 0.9
+ 10878945796464082797148986678211705877197478298691981319010149494537863997149167589785610p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570700p -0.3
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179570710p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571200p 0.9
+ 21757891592928165594297973356423411754394956597383962638020298989075727994298335179571210p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141900p -0.3
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359141910p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142400p 0.9
+ 43515783185856331188595946712846823508789913194767925276040597978151455988596670359142410p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284300p -0.3
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284310p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284800p 0.9
+ 87031566371712662377191893425693647017579826389535850552081195956302911977193340718284810p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569100p -0.3
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569110p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569600p 0.9
+ 174063132743425324754383786851387294035159652779071701104162391912605823954386681436569610p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138700p -0.3
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873138710p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139200p 0.9
+ 348126265486850649508767573702774588070319305558143402208324783825211647908773362873139210p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277900p -0.3
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746277910p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278400p 0.9
+ 696252530973701299017535147405549176140638611116286804416649567650423295817546725746278410p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556300p -0.3
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556310p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556800p 0.9
+ 1392505061947402598035070294811098352281277222232573608833299135300846591635093451492556810p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113100p -0.3
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113110p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113600p 0.9
+ 2785010123894805196070140589622196704562554444465147217666598270601693183270186902985113610p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226700p -0.3
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970226710p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227200p 0.9
+ 5570020247789610392140281179244393409125108888930294435333196541203386366540373805970227210p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453900p -0.3
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940453910p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454400p 0.9
+ 11140040495579220784280562358488786818250217777860588870666393082406772733080747611940454410p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908300p -0.3
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908310p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908800p 0.9
+ 22280080991158441568561124716977573636500435555721177741332786164813545466161495223880908810p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817100p -0.3
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817110p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817600p 0.9
+ 44560161982316883137122249433955147273000871111442355482665572329627090932322990447761817610p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634700p -0.3
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523634710p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635200p 0.9
+ 89120323964633766274244498867910294546001742222884710965331144659254181864645980895523635210p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269900p -0.3
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047269910p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270400p 0.9
+ 178240647929267532548488997735820589092003484445769421930662289318508363729291961791047270410p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540300p -0.3
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540310p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540800p 0.9
+ 356481295858535065096977995471641178184006968891538843861324578637016727458583923582094540810p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081100p -0.3
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081110p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081600p 0.9
+ 712962591717070130193955990943282356368013937783077687722649157274033454917167847164189081610p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162700p -0.3
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378162710p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163200p 0.9
+ 1425925183434140260387911981886564712736027875566155375445298314548066909834335694328378163210p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325900p -0.3
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756325910p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326400p 0.9
+ 2851850366868280520775823963773129425472055751132310750890596629096133819668671388656756326410p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652300p -0.3
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652310p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652800p 0.9
+ 5703700733736561041551647927546258850944111502264621501781193258192267639337342777313512652810p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305100p -0.3
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305110p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305600p 0.9
+ 11407401467473122083103295855092517701888223004529243003562386516384535278674685554627025305610p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610700p -0.3
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050610710p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611200p 0.9
+ 22814802934946244166206591710185035403776446009058486007124773032769070557349371109254050611210p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221900p -0.3
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101221910p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222400p 0.9
+ 45629605869892488332413183420370070807552892018116972014249546065538141114698742218508101222410p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444300p -0.3
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444310p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444800p 0.9
+ 91259211739784976664826366840740141615105784036233944028499092131076282229397484437016202444810p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889100p -0.3
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889110p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889600p 0.9
+ 182518423479569953329652733681480283230211568072467888056998184262152564458794968874032404889610p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778700p -0.3
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809778710p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779200p 0.9
+ 365036846959139906659305467362960566460423136144935776113996368524305128917589937748064809779210p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557900p -0.3
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619557910p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558400p 0.9
+ 730073693918279813318610934725921132920846272289871552227992737048610257835179875496129619558410p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116300p -0.3
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116310p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116800p 0.9
+ 1460147387836559626637221869451842265841692544579743104455985474097220515670359750992259239116810p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233100p -0.3
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233110p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233600p 0.9
+ 2920294775673119253274443738903684531683385089159486208911970948194441031340719501984518478233610p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466700p -0.3
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956466710p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467200p 0.9
+ 5840589551346238506548887477807369063366770178318972417823941896388882062681439003969036956467210p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933900p -0.3
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912933910p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934400p 0.9
+ 11681179102692477013097774955614738126733540356637944835647883792777764125362878007938073912934410p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868300p -0.3
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868310p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868800p 0.9
+ 23362358205384954026195549911229476253467080713275889671295767585555528250725756015876147825868810p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737100p -0.3
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737110p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737600p 0.9
+ 46724716410769908052391099822458952506934161426551779342591535171111056501451512031752295651737610p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474700p -0.3
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303474710p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475200p 0.9
+ 93449432821539816104782199644917905013868322853103558685183070342222113002903024063504591303475210p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949900p -0.3
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606949910p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950400p 0.9
+ 186898865643079632209564399289835810027736645706207117370366140684444226005806048127009182606950410p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900300p -0.3
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900310p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900800p 0.9
+ 373797731286159264419128798579671620055473291412414234740732281368888452011612096254018365213900810p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801100p -0.3
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801110p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801600p 0.9
+ 747595462572318528838257597159343240110946582824828469481464562737776904023224192508036730427801610p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602700p -0.3
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855602710p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603200p 0.9
+ 1495190925144637057676515194318686480221893165649656938962929125475553808046448385016073460855603210p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205900p -0.3
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711205910p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206400p 0.9
+ 2990381850289274115353030388637372960443786331299313877925858250951107616092896770032146921711206410p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412300p -0.3
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412310p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412800p 0.9
+ 5980763700578548230706060777274745920887572662598627755851716501902215232185793540064293843422412810p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825100p -0.3
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825110p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825600p 0.9
+ 11961527401157096461412121554549491841775145325197255511703433003804430464371587080128587686844825610p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650700p -0.3
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689650710p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651200p 0.9
+ 23923054802314192922824243109098983683550290650394511023406866007608860928743174160257175373689651210p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301900p -0.3
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379301910p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302400p 0.9
+ 47846109604628385845648486218197967367100581300789022046813732015217721857486348320514350747379302410p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604300p -0.3
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604310p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604800p 0.9
+ 95692219209256771691296972436395934734201162601578044093627464030435443714972696641028701494758604810p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209100p -0.3
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209110p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209600p 0.9
+ 191384438418513543382593944872791869468402325203156088187254928060870887429945393282057402989517209610p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418700p -0.3
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034418710p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419200p 0.9
+ 382768876837027086765187889745583738936804650406312176374509856121741774859890786564114805979034419210p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837900p -0.3
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068837910p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838400p 0.9
+ 765537753674054173530375779491167477873609300812624352749019712243483549719781573128229611958068838410p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676300p -0.3
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676310p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676800p 0.9
+ 1531075507348108347060751558982334955747218601625248705498039424486967099439563146256459223916137676810p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353100p -0.3
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353110p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353600p 0.9
+ 3062151014696216694121503117964669911494437203250497410996078848973934198879126292512918447832275353610p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706700p -0.3
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550706710p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707200p 0.9
+ 6124302029392433388243006235929339822988874406500994821992157697947868397758252585025836895664550707210p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413900p -0.3
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101413910p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414400p 0.9
+ 12248604058784866776486012471858679645977748813001989643984315395895736795516505170051673791329101414410p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828300p -0.3
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828310p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828800p 0.9
+ 24497208117569733552972024943717359291955497626003979287968630791791473591033010340103347582658202828810p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657100p -0.3
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657110p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657600p 0.9
+ 48994416235139467105944049887434718583910995252007958575937261583582947182066020680206695165316405657610p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314700p -0.3
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811314710p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315200p 0.9
+ 97988832470278934211888099774869437167821990504015917151874523167165894364132041360413390330632811315210p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629900p -0.3
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622629910p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630400p 0.9
+ 195977664940557868423776199549738874335643981008031834303749046334331788728264082720826780661265622630410p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260300p -0.3
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260310p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260800p 0.9
+ 391955329881115736847552399099477748671287962016063668607498092668663577456528165441653561322531245260810p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521100p -0.3
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521110p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521600p 0.9
+ 783910659762231473695104798198955497342575924032127337214996185337327154913056330883307122645062490521610p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042700p -0.3
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981042710p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043200p 0.9
+ 1567821319524462947390209596397910994685151848064254674429992370674654309826112661766614245290124981043210p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085900p -0.3
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962085910p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086400p 0.9
+ 3135642639048925894780419192795821989370303696128509348859984741349308619652225323533228490580249962086410p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172300p -0.3
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172310p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172800p 0.9
+ 6271285278097851789560838385591643978740607392257018697719969482698617239304450647066456981160499924172810p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345100p -0.3
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345110p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345600p 0.9
+ 12542570556195703579121676771183287957481214784514037395439938965397234478608901294132913962320999848345610p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690700p -0.3
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696690710p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691200p 0.9
+ 25085141112391407158243353542366575914962429569028074790879877930794468957217802588265827924641999696691210p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381900p -0.3
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393381910p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382400p 0.9
+ 50170282224782814316486707084733151829924859138056149581759755861588937914435605176531655849283999393382410p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764300p -0.3
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764310p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764800p 0.9
+ 100340564449565628632973414169466303659849718276112299163519511723177875828871210353063311698567998786764810p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529100p -0.3
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529110p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529600p 0.9
+ 200681128899131257265946828338932607319699436552224598327039023446355751657742420706126623397135997573529610p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058700p -0.3
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147058710p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059200p 0.9
+ 401362257798262514531893656677865214639398873104449196654078046892711503315484841412253246794271995147059210p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117900p -0.3
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294117910p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118400p 0.9
+ 802724515596525029063787313355730429278797746208898393308156093785423006630969682824506493588543990294118410p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236300p -0.3
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236310p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236800p 0.9
+ 1605449031193050058127574626711460858557595492417796786616312187570846013261939365649012987177087980588236810p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473100p -0.3
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473110p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473600p 0.9
+ 3210898062386100116255149253422921717115190984835593573232624375141692026523878731298025974354175961176473610p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946700p -0.3
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352946710p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947200p 0.9
+ 6421796124772200232510298506845843434230381969671187146465248750283384053047757462596051948708351922352947210p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893900p -0.3
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705893910p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894400p 0.9
+ 12843592249544400465020597013691686868460763939342374292930497500566768106095514925192103897416703844705894410p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788300p -0.3
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788310p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788800p 0.9
+ 25687184499088800930041194027383373736921527878684748585860995001133536212191029850384207794833407689411788810p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577100p -0.3
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577110p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577600p 0.9
+ 51374368998177601860082388054766747473843055757369497171721990002267072424382059700768415589666815378823577610p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154700p -0.3
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647154710p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155200p 0.9
+ 102748737996355203720164776109533494947686111514738994343443980004534144848764119401536831179333630757647155210p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309900p -0.3
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294309910p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310400p 0.9
+ 205497475992710407440329552219066989895372223029477988686887960009068289697528238803073662358667261515294310410p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620300p -0.3
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620310p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620800p 0.9
+ 410994951985420814880659104438133979790744446058955977373775920018136579395056477606147324717334523030588620810p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241100p -0.3
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241110p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241600p 0.9
+ 821989903970841629761318208876267959581488892117911954747551840036273158790112955212294649434669046061177241610p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482700p -0.3
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354482710p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483200p 0.9
+ 1643979807941683259522636417752535919162977784235823909495103680072546317580225910424589298869338092122354483210p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965900p -0.3
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708965910p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966400p 0.9
+ 3287959615883366519045272835505071838325955568471647818990207360145092635160451820849178597738676184244708966410p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932300p -0.3
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932310p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932800p 0.9
+ 6575919231766733038090545671010143676651911136943295637980414720290185270320903641698357195477352368489417932810p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865100p -0.3
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865110p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865600p 0.9
+ 13151838463533466076181091342020287353303822273886591275960829440580370540641807283396714390954704736978835865610p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730700p -0.3
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671730710p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731200p 0.9
+ 26303676927066932152362182684040574706607644547773182551921658881160741081283614566793428781909409473957671731210p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461900p -0.3
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343461910p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462400p 0.9
+ 52607353854133864304724365368081149413215289095546365103843317762321482162567229133586857563818818947915343462410p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924300p -0.3
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924310p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924800p 0.9
+ 105214707708267728609448730736162298826430578191092730207686635524642964325134458267173715127637637895830686924810p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849100p -0.3
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849110p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849600p 0.9
+ 210429415416535457218897461472324597652861156382185460415373271049285928650268916534347430255275275791661373849610p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698700p -0.3
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747698710p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699200p 0.9
+ 420858830833070914437794922944649195305722312764370920830746542098571857300537833068694860510550551583322747699210p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397900p -0.3
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495397910p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398400p 0.9
+ 841717661666141828875589845889298390611444625528741841661493084197143714601075666137389721021101103166645495398410p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796300p -0.3
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796310p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796800p 0.9
+ 1683435323332283657751179691778596781222889251057483683322986168394287429202151332274779442042202206333290990796810p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593100p -0.3
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593110p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593600p 0.9
+ 3366870646664567315502359383557193562445778502114967366645972336788574858404302664549558884084404412666581981593610p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186700p -0.3
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963186710p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187200p 0.9
+ 6733741293329134631004718767114387124891557004229934733291944673577149716808605329099117768168808825333163963187210p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373900p -0.3
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926373910p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374400p 0.9
+ 13467482586658269262009437534228774249783114008459869466583889347154299433617210658198235536337617650666327926374410p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748300p -0.3
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748310p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748800p 0.9
+ 26934965173316538524018875068457548499566228016919738933167778694308598867234421316396471072675235301332655852748810p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497100p -0.3
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497110p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497600p 0.9
+ 53869930346633077048037750136915096999132456033839477866335557388617197734468842632792942145350470602665311705497610p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994700p -0.3
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410994710p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995200p 0.9
+ 107739860693266154096075500273830193998264912067678955732671114777234395468937685265585884290700941205330623410995210p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989900p -0.3
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821989910p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990400p 0.9
+ 215479721386532308192151000547660387996529824135357911465342229554468790937875370531171768581401882410661246821990410p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980300p -0.3
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980310p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980800p 0.9
+ 430959442773064616384302001095320775993059648270715822930684459108937581875750741062343537162803764821322493643980810p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961100p -0.3
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961110p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961600p 0.9
+ 861918885546129232768604002190641551986119296541431645861368918217875163751501482124687074325607529642644987287961610p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922700p -0.3
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575922710p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923200p 0.9
+ 1723837771092258465537208004381283103972238593082863291722737836435750327503002964249374148651215059285289974575923210p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845900p -0.3
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151845910p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846400p 0.9
+ 3447675542184516931074416008762566207944477186165726583445475672871500655006005928498748297302430118570579949151846410p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692300p -0.3
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692310p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692800p 0.9
+ 6895351084369033862148832017525132415888954372331453166890951345743001310012011856997496594604860237141159898303692810p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385100p -0.3
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385110p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385600p 0.9
+ 13790702168738067724297664035050264831777908744662906333781902691486002620024023713994993189209720474282319796607385610p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770700p -0.3
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214770710p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771200p 0.9
+ 27581404337476135448595328070100529663555817489325812667563805382972005240048047427989986378419440948564639593214771210p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541900p -0.3
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429541910p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542400p 0.9
+ 55162808674952270897190656140201059327111634978651625335127610765944010480096094855979972756838881897129279186429542410p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084300p -0.3
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084310p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084800p 0.9
+ 110325617349904541794381312280402118654223269957303250670255221531888020960192189711959945513677763794258558372859084810p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169100p -0.3
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169110p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169600p 0.9
+ 220651234699809083588762624560804237308446539914606501340510443063776041920384379423919891027355527588517116745718169610p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338700p -0.3
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436338710p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339200p 0.9
+ 441302469399618167177525249121608474616893079829213002681020886127552083840768758847839782054711055177034233491436339210p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677900p -0.3
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872677910p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678400p 0.9
+ 882604938799236334355050498243216949233786159658426005362041772255104167681537517695679564109422110354068466982872678410p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356300p -0.3
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356310p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356800p 0.9
+ 1765209877598472668710100996486433898467572319316852010724083544510208335363075035391359128218844220708136933965745356810p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713100p -0.3
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713110p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713600p 0.9
+ 3530419755196945337420201992972867796935144638633704021448167089020416670726150070782718256437688441416273867931490713610p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426700p -0.3
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981426710p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427200p 0.9
+ 7060839510393890674840403985945735593870289277267408042896334178040833341452300141565436512875376882832547735862981427210p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853900p -0.3
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962853910p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854400p 0.9
+ 14121679020787781349680807971891471187740578554534816085792668356081666682904600283130873025750753765665095471725962854410p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708300p -0.3
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708310p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708800p 0.9
+ 28243358041575562699361615943782942375481157109069632171585336712163333365809200566261746051501507531330190943451925708810p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417100p -0.3
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417110p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417600p 0.9
+ 56486716083151125398723231887565884750962314218139264343170673424326666731618401132523492103003015062660381886903851417610p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834700p -0.3
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702834710p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835200p 0.9
+ 112973432166302250797446463775131769501924628436278528686341346848653333463236802265046984206006030125320763773807702835210p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669900p -0.3
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405669910p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670400p 0.9
+ 225946864332604501594892927550263539003849256872557057372682693697306666926473604530093968412012060250641527547615405670410p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340300p -0.3
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340310p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340800p 0.9
+ 451893728665209003189785855100527078007698513745114114745365387394613333852947209060187936824024120501283055095230811340810p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681100p -0.3
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681110p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681600p 0.9
+ 903787457330418006379571710201054156015397027490228229490730774789226667705894418120375873648048241002566110190461622681610p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362700p -0.3
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245362710p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363200p 0.9
+ 1807574914660836012759143420402108312030794054980456458981461549578453335411788836240751747296096482005132220380923245363210p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725900p -0.3
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490725910p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726400p 0.9
+ 3615149829321672025518286840804216624061588109960912917962923099156906670823577672481503494592192964010264440761846490726410p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452300p -0.3
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452310p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452800p 0.9
+ 7230299658643344051036573681608433248123176219921825835925846198313813341647155344963006989184385928020528881523692981452810p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905100p -0.3
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905110p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905600p 0.9
+ 14460599317286688102073147363216866496246352439843651671851692396627626683294310689926013978368771856041057763047385962905610p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810700p -0.3
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925810710p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811200p 0.9
+ 28921198634573376204146294726433732992492704879687303343703384793255253366588621379852027956737543712082115526094771925811210p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621900p -0.3
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851621910p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622400p 0.9
+ 57842397269146752408292589452867465984985409759374606687406769586510506733177242759704055913475087424164231052189543851622410p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244300p -0.3
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244310p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244800p 0.9
+ 115684794538293504816585178905734931969970819518749213374813539173021013466354485519408111826950174848328462104379087703244810p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489100p -0.3
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489110p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489600p 0.9
+ 231369589076587009633170357811469863939941639037498426749627078346042026932708971038816223653900349696656924208758175406489610p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978700p -0.3
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812978710p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979200p 0.9
+ 462739178153174019266340715622939727879883278074996853499254156692084053865417942077632447307800699393313848417516350812979210p -0.3
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957900p -0.3
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625957910p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958400p 0.9
+ 925478356306348038532681431245879455759766556149993706998508313384168107730835884155264894615601398786627696835032701625958410p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916300p -0.3
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916310p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916800p 0.9
+ 1850956712612696077065362862491758911519533112299987413997016626768336215461671768310529789231202797573255393670065403251916810p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833100p -0.3
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833110p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833600p 0.9
+ 3701913425225392154130725724983517823039066224599974827994033253536672430923343536621059578462405595146510787340130806503833610p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666700p -0.3
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007666710p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667200p 0.9
+ 7403826850450784308261451449967035646078132449199949655988066507073344861846687073242119156924811190293021574680261613007667210p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333900p -0.3
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015333910p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334400p 0.9
+ 14807653700901568616522902899934071292156264898399899311976133014146689723693374146484238313849622380586043149360523226015334410p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668300p -0.3
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668310p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668800p 0.9
+ 29615307401803137233045805799868142584312529796799798623952266028293379447386748292968476627699244761172086298721046452030668810p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337100p -0.3
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337110p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337600p 0.9
+ 59230614803606274466091611599736285168625059593599597247904532056586758894773496585936953255398489522344172597442092904061337610p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674700p -0.3
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122674710p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675200p 0.9
+ 118461229607212548932183223199472570337250119187199194495809064113173517789546993171873906510796979044688345194884185808122675210p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349900p -0.3
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245349910p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350400p 0.9
+ 236922459214425097864366446398945140674500238374398388991618128226347035579093986343747813021593958089376690389768371616245350410p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700300p -0.3
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700310p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700800p 0.9
+ 473844918428850195728732892797890281349000476748796777983236256452694071158187972687495626043187916178753380779536743232490700810p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401100p -0.3
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401110p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401600p 0.9
+ 947689836857700391457465785595780562698000953497593555966472512905388142316375945374991252086375832357506761559073486464981401610p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802700p -0.3
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962802710p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803200p 0.9
+ 1895379673715400782914931571191561125396001906995187111932945025810776284632751890749982504172751664715013523118146972929962803210p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605900p -0.3
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925605910p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606400p 0.9
+ 3790759347430801565829863142383122250792003813990374223865890051621552569265503781499965008345503329430027046236293945859925606410p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212300p -0.3
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212310p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212800p 0.9
+ 7581518694861603131659726284766244501584007627980748447731780103243105138531007562999930016691006658860054092472587891719851212810p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425100p -0.3
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425110p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425600p 0.9
+ 15163037389723206263319452569532489003168015255961496895463560206486210277062015125999860033382013317720108184945175783439702425610p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850700p -0.3
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404850710p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851200p 0.9
+ 30326074779446412526638905139064978006336030511922993790927120412972420554124030251999720066764026635440216369890351566879404851210p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701900p -0.3
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809701910p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702400p 0.9
+ 60652149558892825053277810278129956012672061023845987581854240825944841108248060503999440133528053270880432739780703133758809702410p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404300p -0.3
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404310p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404800p 0.9
+ 121304299117785650106555620556259912025344122047691975163708481651889682216496121007998880267056106541760865479561406267517619404810p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809100p -0.3
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809110p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809600p 0.9
+ 242608598235571300213111241112519824050688244095383950327416963303779364432992242015997760534112213083521730959122812535035238809610p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618700p -0.3
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477618710p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619200p 0.9
+ 485217196471142600426222482225039648101376488190767900654833926607558728865984484031995521068224426167043461918245625070070477619210p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237900p -0.3
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955237910p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238400p 0.9
+ 970434392942285200852444964450079296202752976381535801309667853215117457731968968063991042136448852334086923836491250140140955238410p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476300p -0.3
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476310p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476800p 0.9
+ 1940868785884570401704889928900158592405505952763071602619335706430234915463937936127982084272897704668173847672982500280281910476810p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953100p -0.3
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953110p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953600p 0.9
+ 3881737571769140803409779857800317184811011905526143205238671412860469830927875872255964168545795409336347695345965000560563820953610p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906700p -0.3
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641906710p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907200p 0.9
+ 7763475143538281606819559715600634369622023811052286410477342825720939661855751744511928337091590818672695390691930001121127641907210p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813900p -0.3
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283813910p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814400p 0.9
+ 15526950287076563213639119431201268739244047622104572820954685651441879323711503489023856674183181637345390781383860002242255283814410p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628300p -0.3
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628310p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628800p 0.9
+ 31053900574153126427278238862402537478488095244209145641909371302883758647423006978047713348366363274690781562767720004484510567628810p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257100p -0.3
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257110p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257600p 0.9
+ 62107801148306252854556477724805074956976190488418291283818742605767517294846013956095426696732726549381563125535440008969021135257610p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514700p -0.3
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270514710p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515200p 0.9
+ 124215602296612505709112955449610149913952380976836582567637485211535034589692027912190853393465453098763126251070880017938042270515210p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029900p -0.3
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541029910p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030400p 0.9
+ 248431204593225011418225910899220299827904761953673165135274970423070069179384055824381706786930906197526252502141760035876084541030410p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060300p -0.3
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060310p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060800p 0.9
+ 496862409186450022836451821798440599655809523907346330270549940846140138358768111648763413573861812395052505004283520071752169082060810p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121100p -0.3
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121110p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121600p 0.9
+ 993724818372900045672903643596881199311619047814692660541099881692280276717536223297526827147723624790105010008567040143504338164121610p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242700p -0.3
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328242710p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243200p 0.9
+ 1987449636745800091345807287193762398623238095629385321082199763384560553435072446595053654295447249580210020017134080287008676328243210p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485900p -0.3
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656485910p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486400p 0.9
+ 3974899273491600182691614574387524797246476191258770642164399526769121106870144893190107308590894499160420040034268160574017352656486410p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972300p -0.3
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972310p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972800p 0.9
+ 7949798546983200365383229148775049594492952382517541284328799053538242213740289786380214617181788998320840080068536321148034705312972810p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945100p -0.3
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945110p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945600p 0.9
+ 15899597093966400730766458297550099188985904765035082568657598107076484427480579572760429234363577996641680160137072642296069410625945610p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890700p -0.3
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251890710p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891200p 0.9
+ 31799194187932801461532916595100198377971809530070165137315196214152968854961159145520858468727155993283360320274145284592138821251891210p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781900p -0.3
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503781910p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782400p 0.9
+ 63598388375865602923065833190200396755943619060140330274630392428305937709922318291041716937454311986566720640548290569184277642503782410p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564300p -0.3
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564310p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564800p 0.9
+ 127196776751731205846131666380400793511887238120280660549260784856611875419844636582083433874908623973133441281096581138368555285007564810p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129100p -0.3
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129110p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129600p 0.9
+ 254393553503462411692263332760801587023774476240561321098521569713223750839689273164166867749817247946266882562193162276737110570015129610p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258700p -0.3
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030258710p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259200p 0.9
+ 508787107006924823384526665521603174047548952481122642197043139426447501679378546328333735499634495892533765124386324553474221140030259210p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517900p -0.3
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060517910p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518400p 0.9
+ 1017574214013849646769053331043206348095097904962245284394086278852895003358757092656667470999268991785067530248772649106948442280060518410p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036300p -0.3
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036310p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036800p 0.9
+ 2035148428027699293538106662086412696190195809924490568788172557705790006717514185313334941998537983570135060497545298213896884560121036810p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073100p -0.3
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073110p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073600p 0.9
+ 4070296856055398587076213324172825392380391619848981137576345115411580013435028370626669883997075967140270120995090596427793769120242073610p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146700p -0.3
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484146710p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147200p 0.9
+ 8140593712110797174152426648345650784760783239697962275152690230823160026870056741253339767994151934280540241990181192855587538240484147210p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293900p -0.3
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968293910p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294400p 0.9
+ 16281187424221594348304853296691301569521566479395924550305380461646320053740113482506679535988303868561080483980362385711175076480968294410p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588300p -0.3
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588310p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588800p 0.9
+ 32562374848443188696609706593382603139043132958791849100610760923292640107480226965013359071976607737122160967960724771422350152961936588810p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177100p -0.3
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177110p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177600p 0.9
+ 65124749696886377393219413186765206278086265917583698201221521846585280214960453930026718143953215474244321935921449542844700305923873177610p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354700p -0.3
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746354710p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355200p 0.9
+ 130249499393772754786438826373530412556172531835167396402443043693170560429920907860053436287906430948488643871842899085689400611847746355210p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709900p -0.3
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492709910p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710400p 0.9
+ 260498998787545509572877652747060825112345063670334792804886087386341120859841815720106872575812861896977287743685798171378801223695492710410p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420300p -0.3
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420310p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420800p 0.9
+ 520997997575091019145755305494121650224690127340669585609772174772682241719683631440213745151625723793954575487371596342757602447390985420810p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841100p -0.3
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841110p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841600p 0.9
+ 1041995995150182038291510610988243300449380254681339171219544349545364483439367262880427490303251447587909150974743192685515204894781970841610p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682700p -0.3
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941682710p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683200p 0.9
+ 2083991990300364076583021221976486600898760509362678342439088699090728966878734525760854980606502895175818301949486385371030409789563941683210p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365900p -0.3
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883365910p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366400p 0.9
+ 4167983980600728153166042443952973201797521018725356684878177398181457933757469051521709961213005790351636603898972770742060819579127883366410p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732300p -0.3
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732310p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732800p 0.9
+ 8335967961201456306332084887905946403595042037450713369756354796362915867514938103043419922426011580703273207797945541484121639158255766732810p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465100p -0.3
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465110p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465600p 0.9
+ 16671935922402912612664169775811892807190084074901426739512709592725831735029876206086839844852023161406546415595891082968243278316511533465610p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930700p -0.3
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066930710p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931200p 0.9
+ 33343871844805825225328339551623785614380168149802853479025419185451663470059752412173679689704046322813092831191782165936486556633023066931210p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861900p -0.3
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133861910p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862400p 0.9
+ 66687743689611650450656679103247571228760336299605706958050838370903326940119504824347359379408092645626185662383564331872973113266046133862410p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724300p -0.3
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724310p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724800p 0.9
+ 133375487379223300901313358206495142457520672599211413916101676741806653880239009648694718758816185291252371324767128663745946226532092267724810p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449100p -0.3
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449110p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449600p 0.9
+ 266750974758446601802626716412990284915041345198422827832203353483613307760478019297389437517632370582504742649534257327491892453064184535449610p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898700p -0.3
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070898710p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899200p 0.9
+ 533501949516893203605253432825980569830082690396845655664406706967226615520956038594778875035264741165009485299068514654983784906128369070899210p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797900p -0.3
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141797910p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798400p 0.9
+ 1067003899033786407210506865651961139660165380793691311328813413934453231041912077189557750070529482330018970598137029309967569812256738141798410p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596300p -0.3
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596310p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596800p 0.9
+ 2134007798067572814421013731303922279320330761587382622657626827868906462083824154379115500141058964660037941196274058619935139624513476283596810p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193100p -0.3
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193110p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193600p 0.9
+ 4268015596135145628842027462607844558640661523174765245315253655737812924167648308758231000282117929320075882392548117239870279249026952567193610p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386700p -0.3
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134386710p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387200p 0.9
+ 8536031192270291257684054925215689117281323046349530490630507311475625848335296617516462000564235858640151764785096234479740558498053905134387210p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773900p -0.3
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268773910p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774400p 0.9
+ 17072062384540582515368109850431378234562646092699060981261014622951251696670593235032924001128471717280303529570192468959481116996107810268774410p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548300p -0.3
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548310p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548800p 0.9
+ 34144124769081165030736219700862756469125292185398121962522029245902503393341186470065848002256943434560607059140384937918962233992215620537548810p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097100p -0.3
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097110p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097600p 0.9
+ 68288249538162330061472439401725512938250584370796243925044058491805006786682372940131696004513886869121214118280769875837924467984431241075097610p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194700p -0.3
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150194710p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195200p 0.9
+ 136576499076324660122944878803451025876501168741592487850088116983610013573364745880263392009027773738242428236561539751675848935968862482150195210p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389900p -0.3
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300389910p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390400p 0.9
+ 273152998152649320245889757606902051753002337483184975700176233967220027146729491760526784018055547476484856473123079503351697871937724964300390410p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780300p -0.3
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780310p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780800p 0.9
+ 546305996305298640491779515213804103506004674966369951400352467934440054293458983521053568036111094952969712946246159006703395743875449928600780810p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561100p -0.3
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561110p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561600p 0.9
+ 1092611992610597280983559030427608207012009349932739902800704935868880108586917967042107136072222189905939425892492318013406791487750899857201561610p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122700p -0.3
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403122710p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123200p 0.9
+ 2185223985221194561967118060855216414024018699865479805601409871737760217173835934084214272144444379811878851784984636026813582975501799714403123210p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245900p -0.3
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806245910p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246400p 0.9
+ 4370447970442389123934236121710432828048037399730959611202819743475520434347671868168428544288888759623757703569969272053627165951003599428806246410p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492300p -0.3
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492310p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492800p 0.9
+ 8740895940884778247868472243420865656096074799461919222405639486951040868695343736336857088577777519247515407139938544107254331902007198857612492810p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985100p -0.3
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985110p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985600p 0.9
+ 17481791881769556495736944486841731312192149598923838444811278973902081737390687472673714177155555038495030814279877088214508663804014397715224985610p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970700p -0.3
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449970710p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971200p 0.9
+ 34963583763539112991473888973683462624384299197847676889622557947804163474781374945347428354311110076990061628559754176429017327608028795430449971210p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941900p -0.3
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899941910p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942400p 0.9
+ 69927167527078225982947777947366925248768598395695353779245115895608326949562749890694856708622220153980123257119508352858034655216057590860899942410p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884300p -0.3
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884310p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884800p 0.9
+ 139854335054156451965895555894733850497537196791390707558490231791216653899125499781389713417244440307960246514239016705716069310432115181721799884810p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769100p -0.3
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769110p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769600p 0.9
+ 279708670108312903931791111789467700995074393582781415116980463582433307798250999562779426834488880615920493028478033411432138620864230363443599769610p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538700p -0.3
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199538710p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539200p 0.9
+ 559417340216625807863582223578935401990148787165562830233960927164866615596501999125558853668977761231840986056956066822864277241728460726887199539210p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077900p -0.3
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399077910p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078400p 0.9
+ 1118834680433251615727164447157870803980297574331125660467921854329733231193003998251117707337955522463681972113912133645728554483456921453774399078410p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156300p -0.3
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156310p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156800p 0.9
+ 2237669360866503231454328894315741607960595148662251320935843708659466462386007996502235414675911044927363944227824267291457108966913842907548798156810p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313100p -0.3
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313110p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313600p 0.9
+ 4475338721733006462908657788631483215921190297324502641871687417318932924772015993004470829351822089854727888455648534582914217933827685815097596313610p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626700p -0.3
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192626710p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627200p 0.9
+ 8950677443466012925817315577262966431842380594649005283743374834637865849544031986008941658703644179709455776911297069165828435867655371630195192627210p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253900p -0.3
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385253910p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254400p 0.9
+ 17901354886932025851634631154525932863684761189298010567486749669275731699088063972017883317407288359418911553822594138331656871735310743260390385254410p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508300p -0.3
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508310p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508800p 0.9
+ 35802709773864051703269262309051865727369522378596021134973499338551463398176127944035766634814576718837823107645188276663313743470621486520780770508810p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017100p -0.3
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017110p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017600p 0.9
+ 71605419547728103406538524618103731454739044757192042269946998677102926796352255888071533269629153437675646215290376553326627486941242973041561541017610p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034700p -0.3
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082034710p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035200p 0.9
+ 143210839095456206813077049236207462909478089514384084539893997354205853592704511776143066539258306875351292430580753106653254973882485946083123082035210p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069900p -0.3
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164069910p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070400p 0.9
+ 286421678190912413626154098472414925818956179028768169079787994708411707185409023552286133078516613750702584861161506213306509947764971892166246164070410p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140300p -0.3
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140310p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140800p 0.9
+ 572843356381824827252308196944829851637912358057536338159575989416823414370818047104572266157033227501405169722323012426613019895529943784332492328140810p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281100p -0.3
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281110p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281600p 0.9
+ 1145686712763649654504616393889659703275824716115072676319151978833646828741636094209144532314066455002810339444646024853226039791059887568664984656281610p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562700p -0.3
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312562710p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563200p 0.9
+ 2291373425527299309009232787779319406551649432230145352638303957667293657483272188418289064628132910005620678889292049706452079582119775137329969312563210p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125900p -0.3
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625125910p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126400p 0.9
+ 4582746851054598618018465575558638813103298864460290705276607915334587314966544376836578129256265820011241357778584099412904159164239550274659938625126410p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252300p -0.3
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252310p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252800p 0.9
+ 9165493702109197236036931151117277626206597728920581410553215830669174629933088753673156258512531640022482715557168198825808318328479100549319877250252810p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505100p -0.3
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505110p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505600p 0.9
+ 18330987404218394472073862302234555252413195457841162821106431661338349259866177507346312517025063280044965431114336397651616636656958201098639754500505610p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010700p -0.3
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001010710p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011200p 0.9
+ 36661974808436788944147724604469110504826390915682325642212863322676698519732355014692625034050126560089930862228672795303233273313916402197279509001011210p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021900p -0.3
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002021910p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022400p 0.9
+ 73323949616873577888295449208938221009652781831364651284425726645353397039464710029385250068100253120179861724457345590606466546627832804394559018002022410p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044300p -0.3
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044310p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044800p 0.9
+ 146647899233747155776590898417876442019305563662729302568851453290706794078929420058770500136200506240359723448914691181212933093255665608789118036004044810p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089100p -0.3
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089110p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089600p 0.9
+ 293295798467494311553181796835752884038611127325458605137702906581413588157858840117541000272401012480719446897829382362425866186511331217578236072008089610p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178700p -0.3
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016178710p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179200p 0.9
+ 586591596934988623106363593671505768077222254650917210275405813162827176315717680235082000544802024961438893795658764724851732373022662435156472144016179210p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357900p -0.3
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032357910p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358400p 0.9
+ 1173183193869977246212727187343011536154444509301834420550811626325654352631435360470164001089604049922877787591317529449703464746045324870312944288032358410p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716300p -0.3
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716310p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716800p 0.9
+ 2346366387739954492425454374686023072308889018603668841101623252651308705262870720940328002179208099845755575182635058899406929492090649740625888576064716810p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433100p -0.3
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433110p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433600p 0.9
+ 4692732775479908984850908749372046144617778037207337682203246505302617410525741441880656004358416199691511150365270117798813858984181299481251777152129433610p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866700p -0.3
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258866710p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867200p 0.9
+ 9385465550959817969701817498744092289235556074414675364406493010605234821051482883761312008716832399383022300730540235597627717968362598962503554304258867210p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733900p -0.3
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517733910p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734400p 0.9
+ 18770931101919635939403634997488184578471112148829350728812986021210469642102965767522624017433664798766044601461080471195255435936725197925007108608517734410p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468300p -0.3
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468310p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468800p 0.9
+ 37541862203839271878807269994976369156942224297658701457625972042420939284205931535045248034867329597532089202922160942390510871873450395850014217217035468810p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937100p -0.3
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937110p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937600p 0.9
+ 75083724407678543757614539989952738313884448595317402915251944084841878568411863070090496069734659195064178405844321884781021743746900791700028434434070937610p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874700p -0.3
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141874710p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875200p 0.9
+ 150167448815357087515229079979905476627768897190634805830503888169683757136823726140180992139469318390128356811688643769562043487493801583400056868868141875210p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749900p -0.3
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283749910p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750400p 0.9
+ 300334897630714175030458159959810953255537794381269611661007776339367514273647452280361984278938636780256713623377287539124086974987603166800113737736283750410p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500300p -0.3
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500310p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500800p 0.9
+ 600669795261428350060916319919621906511075588762539223322015552678735028547294904560723968557877273560513427246754575078248173949975206333600227475472567500810p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001100p -0.3
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001110p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001600p 0.9
+ 1201339590522856700121832639839243813022151177525078446644031105357470057094589809121447937115754547121026854493509150156496347899950412667200454950945135001610p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002700p -0.3
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270002710p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003200p 0.9
+ 2402679181045713400243665279678487626044302355050156893288062210714940114189179618242895874231509094242053708987018300312992695799900825334400909901890270003210p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005900p -0.3
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540005910p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006400p 0.9
+ 4805358362091426800487330559356975252088604710100313786576124421429880228378359236485791748463018188484107417974036600625985391599801650668801819803780540006410p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012300p -0.3
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012310p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012800p 0.9
+ 9610716724182853600974661118713950504177209420200627573152248842859760456756718472971583496926036376968214835948073201251970783199603301337603639607561080012810p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025100p -0.3
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025110p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025600p 0.9
+ 19221433448365707201949322237427901008354418840401255146304497685719520913513436945943166993852072753936429671896146402503941566399206602675207279215122160025610p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050700p -0.3
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320050710p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051200p 0.9
+ 38442866896731414403898644474855802016708837680802510292608995371439041827026873891886333987704145507872859343792292805007883132798413205350414558430244320051210p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101900p -0.3
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640101910p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102400p 0.9
+ 76885733793462828807797288949711604033417675361605020585217990742878083654053747783772667975408291015745718687584585610015766265596826410700829116860488640102410p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204300p -0.3
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204310p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204800p 0.9
+ 153771467586925657615594577899423208066835350723210041170435981485756167308107495567545335950816582031491437375169171220031532531193652821401658233720977280204810p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409100p -0.3
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409110p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409600p 0.9
+ 307542935173851315231189155798846416133670701446420082340871962971512334616214991135090671901633164062982874750338342440063065062387305642803316467441954560409610p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818700p -0.3
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120818710p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819200p 0.9
+ 615085870347702630462378311597692832267341402892840164681743925943024669232429982270181343803266328125965749500676684880126130124774611285606632934883909120819210p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637900p -0.3
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241637910p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638400p 0.9
+ 1230171740695405260924756623195385664534682805785680329363487851886049338464859964540362687606532656251931499001353369760252260249549222571213265869767818241638410p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276300p -0.3
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276310p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276800p 0.9
+ 2460343481390810521849513246390771329069365611571360658726975703772098676929719929080725375213065312503862998002706739520504520499098445142426531739535636483276810p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553100p -0.3
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553110p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553600p 0.9
+ 4920686962781621043699026492781542658138731223142721317453951407544197353859439858161450750426130625007725996005413479041009040998196890284853063479071272966553610p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106700p -0.3
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933106710p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107200p 0.9
+ 9841373925563242087398052985563085316277462446285442634907902815088394707718879716322901500852261250015451992010826958082018081996393780569706126958142545933107210p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213900p -0.3
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866213910p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214400p 0.9
+ 19682747851126484174796105971126170632554924892570885269815805630176789415437759432645803001704522500030903984021653916164036163992787561139412253916285091866214410p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428300p -0.3
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428310p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428800p 0.9
+ 39365495702252968349592211942252341265109849785141770539631611260353578830875518865291606003409045000061807968043307832328072327985575122278824507832570183732428810p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857100p -0.3
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857110p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857600p 0.9
+ 78730991404505936699184423884504682530219699570283541079263222520707157661751037730583212006818090000123615936086615664656144655971150244557649015665140367464857610p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714700p -0.3
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929714710p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715200p 0.9
+ 157461982809011873398368847769009365060439399140567082158526445041414315323502075461166424013636180000247231872173231329312289311942300489115298031330280734929715210p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429900p -0.3
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859429910p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430400p 0.9
+ 314923965618023746796737695538018730120878798281134164317052890082828630647004150922332848027272360000494463744346462658624578623884600978230596062660561469859430410p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860300p -0.3
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860310p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860800p 0.9
+ 629847931236047493593475391076037460241757596562268328634105780165657261294008301844665696054544720000988927488692925317249157247769201956461192125321122939718860810p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721100p -0.3
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721110p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721600p 0.9
+ 1259695862472094987186950782152074920483515193124536657268211560331314522588016603689331392109089440001977854977385850634498314495538403912922384250642245879437721610p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442700p -0.3
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875442710p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443200p 0.9
+ 2519391724944189974373901564304149840967030386249073314536423120662629045176033207378662784218178880003955709954771701268996628991076807825844768501284491758875443210p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885900p -0.3
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750885910p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886400p 0.9
+ 5038783449888379948747803128608299681934060772498146629072846241325258090352066414757325568436357760007911419909543402537993257982153615651689537002568983517750886410p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772300p -0.3
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772310p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772800p 0.9
+ 10077566899776759897495606257216599363868121544996293258145692482650516180704132829514651136872715520015822839819086805075986515964307231303379074005137967035501772810p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545100p -0.3
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545110p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545600p 0.9
+ 20155133799553519794991212514433198727736243089992586516291384965301032361408265659029302273745431040031645679638173610151973031928614462606758148010275934071003545610p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090700p -0.3
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007090710p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091200p 0.9
+ 40310267599107039589982425028866397455472486179985173032582769930602064722816531318058604547490862080063291359276347220303946063857228925213516296020551868142007091210p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181900p -0.3
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014181910p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182400p 0.9
+ 80620535198214079179964850057732794910944972359970346065165539861204129445633062636117209094981724160126582718552694440607892127714457850427032592041103736284014182410p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364300p -0.3
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364310p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364800p 0.9
+ 161241070396428158359929700115465589821889944719940692130331079722408258891266125272234418189963448320253165437105388881215784255428915700854065184082207472568028364810p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729100p -0.3
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729110p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729600p 0.9
+ 322482140792856316719859400230931179643779889439881384260662159444816517782532250544468836379926896640506330874210777762431568510857831401708130368164414945136056729610p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458700p -0.3
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113458710p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459200p 0.9
+ 644964281585712633439718800461862359287559778879762768521324318889633035565064501088937672759853793281012661748421555524863137021715662803416260736328829890272113459210p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917900p -0.3
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226917910p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918400p 0.9
+ 1289928563171425266879437600923724718575119557759525537042648637779266071130129002177875345519707586562025323496843111049726274043431325606832521472657659780544226918410p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836300p -0.3
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836310p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836800p 0.9
+ 2579857126342850533758875201847449437150239115519051074085297275558532142260258004355750691039415173124050646993686222099452548086862651213665042945315319561088453836810p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673100p -0.3
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673110p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673600p 0.9
+ 5159714252685701067517750403694898874300478231038102148170594551117064284520516008711501382078830346248101293987372444198905096173725302427330085890630639122176907673610p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346700p -0.3
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815346710p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347200p 0.9
+ 10319428505371402135035500807389797748600956462076204296341189102234128569041032017423002764157660692496202587974744888397810192347450604854660171781261278244353815347210p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693900p -0.3
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630693910p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694400p 0.9
+ 20638857010742804270071001614779595497201912924152408592682378204468257138082064034846005528315321384992405175949489776795620384694901209709320343562522556488707630694410p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388300p -0.3
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388310p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388800p 0.9
+ 41277714021485608540142003229559190994403825848304817185364756408936514276164128069692011056630642769984810351898979553591240769389802419418640687125045112977415261388810p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777100p -0.3
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777110p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777600p 0.9
+ 82555428042971217080284006459118381988807651696609634370729512817873028552328256139384022113261285539969620703797959107182481538779604838837281374250090225954830522777610p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554700p -0.3
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045554710p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555200p 0.9
+ 165110856085942434160568012918236763977615303393219268741459025635746057104656512278768044226522571079939241407595918214364963077559209677674562748500180451909661045555210p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109900p -0.3
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091109910p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110400p 0.9
+ 330221712171884868321136025836473527955230606786438537482918051271492114209313024557536088453045142159878482815191836428729926155118419355349125497000360903819322091110410p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220300p -0.3
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220310p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220800p 0.9
+ 660443424343769736642272051672947055910461213572877074965836102542984228418626049115072176906090284319756965630383672857459852310236838710698250994000721807638644182220810p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441100p -0.3
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441110p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441600p 0.9
+ 1320886848687539473284544103345894111820922427145754149931672205085968456837252098230144353812180568639513931260767345714919704620473677421396501988001443615277288364441610p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882700p -0.3
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728882710p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883200p 0.9
+ 2641773697375078946569088206691788223641844854291508299863344410171936913674504196460288707624361137279027862521534691429839409240947354842793003976002887230554576728883210p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765900p -0.3
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457765910p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766400p 0.9
+ 5283547394750157893138176413383576447283689708583016599726688820343873827349008392920577415248722274558055725043069382859678818481894709685586007952005774461109153457766410p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532300p -0.3
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532310p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532800p 0.9
+ 10567094789500315786276352826767152894567379417166033199453377640687747654698016785841154830497444549116111450086138765719357636963789419371172015904011548922218306915532810p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065100p -0.3
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065110p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065600p 0.9
+ 21134189579000631572552705653534305789134758834332066398906755281375495309396033571682309660994889098232222900172277531438715273927578838742344031808023097844436613831065610p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130700p -0.3
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662130710p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131200p 0.9
+ 42268379158001263145105411307068611578269517668664132797813510562750990618792067143364619321989778196464445800344555062877430547855157677484688063616046195688873227662131210p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261900p -0.3
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324261910p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262400p 0.9
+ 84536758316002526290210822614137223156539035337328265595627021125501981237584134286729238643979556392928891600689110125754861095710315354969376127232092391377746455324262410p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524300p -0.3
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524310p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524800p 0.9
+ 169073516632005052580421645228274446313078070674656531191254042251003962475168268573458477287959112785857783201378220251509722191420630709938752254464184782755492910648524810p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049100p -0.3
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049110p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049600p 0.9
+ 338147033264010105160843290456548892626156141349313062382508084502007924950336537146916954575918225571715566402756440503019444382841261419877504508928369565510985821297049610p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098700p -0.3
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594098710p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099200p 0.9
+ 676294066528020210321686580913097785252312282698626124765016169004015849900673074293833909151836451143431132805512881006038888765682522839755009017856739131021971642594099210p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197900p -0.3
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188197910p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198400p 0.9
+ 1352588133056040420643373161826195570504624565397252249530032338008031699801346148587667818303672902286862265611025762012077777531365045679510018035713478262043943285188198410p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396300p -0.3
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396310p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396800p 0.9
+ 2705176266112080841286746323652391141009249130794504499060064676016063399602692297175335636607345804573724531222051524024155555062730091359020036071426956524087886570376396810p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793100p -0.3
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793110p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793600p 0.9
+ 5410352532224161682573492647304782282018498261589008998120129352032126799205384594350671273214691609147449062444103048048311110125460182718040072142853913048175773140752793610p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586700p -0.3
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505586710p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587200p 0.9
+ 10820705064448323365146985294609564564036996523178017996240258704064253598410769188701342546429383218294898124888206096096622220250920365436080144285707826096351546281505587210p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173900p -0.3
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011173910p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174400p 0.9
+ 21641410128896646730293970589219129128073993046356035992480517408128507196821538377402685092858766436589796249776412192193244440501840730872160288571415652192703092563011174410p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348300p -0.3
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348310p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348800p 0.9
+ 43282820257793293460587941178438258256147986092712071984961034816257014393643076754805370185717532873179592499552824384386488881003681461744320577142831304385406185126022348810p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697100p -0.3
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697110p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697600p 0.9
+ 86565640515586586921175882356876516512295972185424143969922069632514028787286153509610740371435065746359184999105648768772977762007362923488641154285662608770812370252044697610p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394700p -0.3
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089394710p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395200p 0.9
+ 173131281031173173842351764713753033024591944370848287939844139265028057574572307019221480742870131492718369998211297537545955524014725846977282308571325217541624740504089395210p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789900p -0.3
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178789910p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790400p 0.9
+ 346262562062346347684703529427506066049183888741696575879688278530056115149144614038442961485740262985436739996422595075091911048029451693954564617142650435083249481008178790410p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580300p -0.3
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580310p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580800p 0.9
+ 692525124124692695369407058855012132098367777483393151759376557060112230298289228076885922971480525970873479992845190150183822096058903387909129234285300870166498962016357580810p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161100p -0.3
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161110p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161600p 0.9
+ 1385050248249385390738814117710024264196735554966786303518753114120224460596578456153771845942961051941746959985690380300367644192117806775818258468570601740332997924032715161610p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322700p -0.3
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430322710p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323200p 0.9
+ 2770100496498770781477628235420048528393471109933572607037506228240448921193156912307543691885922103883493919971380760600735288384235613551636516937141203480665995848065430323210p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645900p -0.3
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860645910p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646400p 0.9
+ 5540200992997541562955256470840097056786942219867145214075012456480897842386313824615087383771844207766987839942761521201470576768471227103273033874282406961331991696130860646410p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292300p -0.3
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292310p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292800p 0.9
+ 11080401985995083125910512941680194113573884439734290428150024912961795684772627649230174767543688415533975679885523042402941153536942454206546067748564813922663983392261721292810p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585100p -0.3
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585110p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585600p 0.9
+ 22160803971990166251821025883360388227147768879468580856300049825923591369545255298460349535087376831067951359771046084805882307073884908413092135497129627845327966784523442585610p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170700p -0.3
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885170710p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171200p 0.9
+ 44321607943980332503642051766720776454295537758937161712600099651847182739090510596920699070174753662135902719542092169611764614147769816826184270994259255690655933569046885171210p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341900p -0.3
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770341910p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342400p 0.9
+ 88643215887960665007284103533441552908591075517874323425200199303694365478181021193841398140349507324271805439084184339223529228295539633652368541988518511381311867138093770342410p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684300p -0.3
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684310p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684800p 0.9
+ 177286431775921330014568207066883105817182151035748646850400398607388730956362042387682796280699014648543610878168368678447058456591079267304737083977037022762623734276187540684810p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369100p -0.3
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369110p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369600p 0.9
+ 354572863551842660029136414133766211634364302071497293700800797214777461912724084775365592561398029297087221756336737356894116913182158534609474167954074045525247468552375081369610p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738700p -0.3
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162738710p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739200p 0.9
+ 709145727103685320058272828267532423268728604142994587401601594429554923825448169550731185122796058594174443512673474713788233826364317069218948335908148091050494937104750162739210p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477900p -0.3
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325477910p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478400p 0.9
+ 1418291454207370640116545656535064846537457208285989174803203188859109847650896339101462370245592117188348887025346949427576467652728634138437896671816296182100989874209500325478410p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956300p -0.3
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956310p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956800p 0.9
+ 2836582908414741280233091313070129693074914416571978349606406377718219695301792678202924740491184234376697774050693898855152935305457268276875793343632592364201979748419000650956810p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913100p -0.3
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913110p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913600p 0.9
+ 5673165816829482560466182626140259386149828833143956699212812755436439390603585356405849480982368468753395548101387797710305870610914536553751586687265184728403959496838001301913610p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826700p -0.3
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603826710p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827200p 0.9
+ 11346331633658965120932365252280518772299657666287913398425625510872878781207170712811698961964736937506791096202775595420611741221829073107503173374530369456807918993676002603827210p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653900p -0.3
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207653910p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654400p 0.9
+ 22692663267317930241864730504561037544599315332575826796851251021745757562414341425623397923929473875013582192405551190841223482443658146215006346749060738913615837987352005207654410p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308300p -0.3
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308310p 0.9
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308800p 0.9
+ 45385326534635860483729461009122075089198630665151653593702502043491515124828682851246795847858947750027164384811102381682446964887316292430012693498121477827231675974704010415308810p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617100p -0.3
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617110p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617600p 0.9
+ 90770653069271720967458922018244150178397261330303307187405004086983030249657365702493591695717895500054328769622204763364893929774632584860025386996242955654463351949408020830617610p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234700p -0.3
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661234710p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235200p 0.9
+ 181541306138543441934917844036488300356794522660606614374810008173966060499314731404987183391435791000108657539244409526729787859549265169720050773992485911308926703898816041661235210p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469900p -0.3
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322469910p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470400p 0.9
+ 363082612277086883869835688072976600713589045321213228749620016347932120998629462809974366782871582000217315078488819053459575719098530339440101547984971822617853407797632083322470410p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940300p -0.3
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940310p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940800p 0.9
+ 726165224554173767739671376145953201427178090642426457499240032695864241997258925619948733565743164000434630156977638106919151438197060678880203095969943645235706815595264166644940810p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881100p -0.3
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881110p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881600p 0.9
+ 1452330449108347535479342752291906402854356181284852914998480065391728483994517851239897467131486328000869260313955276213838302876394121357760406191939887290471413631190528333289881610p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762700p -0.3
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579762710p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763200p 0.9
+ 2904660898216695070958685504583812805708712362569705829996960130783456967989035702479794934262972656001738520627910552427676605752788242715520812383879774580942827262381056666579763210p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525900p -0.3
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159525910p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526400p 0.9
+ 5809321796433390141917371009167625611417424725139411659993920261566913935978071404959589868525945312003477041255821104855353211505576485431041624767759549161885654524762113333159526410p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052300p -0.3
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052310p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052800p 0.9
+ 11618643592866780283834742018335251222834849450278823319987840523133827871956142809919179737051890624006954082511642209710706423011152970862083249535519098323771309049524226666319052810p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105100p -0.3
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105110p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105600p 0.9
+ 23237287185733560567669484036670502445669698900557646639975681046267655743912285619838359474103781248013908165023284419421412846022305941724166499071038196647542618099048453332638105610p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210700p -0.3
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276210710p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211200p 0.9
+ 46474574371467121135338968073341004891339397801115293279951362092535311487824571239676718948207562496027816330046568838842825692044611883448332998142076393295085236198096906665276211210p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421900p -0.3
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552421910p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422400p 0.9
+ 92949148742934242270677936146682009782678795602230586559902724185070622975649142479353437896415124992055632660093137677685651384089223766896665996284152786590170472396193813330552422410p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844300p -0.3
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844310p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844800p 0.9
+ 185898297485868484541355872293364019565357591204461173119805448370141245951298284958706875792830249984111265320186275355371302768178447533793331992568305573180340944792387626661104844810p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689100p -0.3
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689110p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689600p 0.9
+ 371796594971736969082711744586728039130715182408922346239610896740282491902596569917413751585660499968222530640372550710742605536356895067586663985136611146360681889584775253322209689610p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378700p -0.3
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419378710p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379200p 0.9
+ 743593189943473938165423489173456078261430364817844692479221793480564983805193139834827503171320999936445061280745101421485211072713790135173327970273222292721363779169550506644419379210p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757900p -0.3
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838757910p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758400p 0.9
+ 1487186379886947876330846978346912156522860729635689384958443586961129967610386279669655006342641999872890122561490202842970422145427580270346655940546444585442727558339101013288838758410p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516300p -0.3
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516310p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516800p 0.9
+ 2974372759773895752661693956693824313045721459271378769916887173922259935220772559339310012685283999745780245122980405685940844290855160540693311881092889170885455116678202026577677516810p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033100p -0.3
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033110p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033600p 0.9
+ 5948745519547791505323387913387648626091442918542757539833774347844519870441545118678620025370567999491560490245960811371881688581710321081386623762185778341770910233356404053155355033610p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066700p -0.3
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710066710p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067200p 0.9
+ 11897491039095583010646775826775297252182885837085515079667548695689039740883090237357240050741135998983120980491921622743763377163420642162773247524371556683541820466712808106310710067210p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133900p -0.3
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420133910p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134400p 0.9
+ 23794982078191166021293551653550594504365771674171030159335097391378079481766180474714480101482271997966241960983843245487526754326841284325546495048743113367083640933425616212621420134410p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268300p -0.3
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268310p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268800p 0.9
+ 47589964156382332042587103307101189008731543348342060318670194782756158963532360949428960202964543995932483921967686490975053508653682568651092990097486226734167281866851232425242840268810p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537100p -0.3
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537110p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537600p 0.9
+ 95179928312764664085174206614202378017463086696684120637340389565512317927064721898857920405929087991864967843935372981950107017307365137302185980194972453468334563733702464850485680537610p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074700p -0.3
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361074710p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075200p 0.9
+ 190359856625529328170348413228404756034926173393368241274680779131024635854129443797715840811858175983729935687870745963900214034614730274604371960389944906936669127467404929700971361075210p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149900p -0.3
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722149910p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150400p 0.9
+ 380719713251058656340696826456809512069852346786736482549361558262049271708258887595431681623716351967459871375741491927800428069229460549208743920779889813873338254934809859401942722150410p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300300p -0.3
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300310p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300800p 0.9
+ 761439426502117312681393652913619024139704693573472965098723116524098543416517775190863363247432703934919742751482983855600856138458921098417487841559779627746676509869619718803885444300810p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601100p -0.3
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601110p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601600p 0.9
+ 1522878853004234625362787305827238048279409387146945930197446233048197086833035550381726726494865407869839485502965967711201712276917842196834975683119559255493353019739239437607770888601610p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202700p -0.3
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777202710p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203200p 0.9
+ 3045757706008469250725574611654476096558818774293891860394892466096394173666071100763453452989730815739678971005931935422403424553835684393669951366239118510986706039478478875215541777203210p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405900p -0.3
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554405910p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406400p 0.9
+ 6091515412016938501451149223308952193117637548587783720789784932192788347332142201526906905979461631479357942011863870844806849107671368787339902732478237021973412078956957750431083554406410p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812300p -0.3
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812310p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812800p 0.9
+ 12183030824033877002902298446617904386235275097175567441579569864385576694664284403053813811958923262958715884023727741689613698215342737574679805464956474043946824157913915500862167108812810p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625100p -0.3
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625110p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625600p 0.9
+ 24366061648067754005804596893235808772470550194351134883159139728771153389328568806107627623917846525917431768047455483379227396430685475149359610929912948087893648315827831001724334217625610p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250700p -0.3
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435250710p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251200p 0.9
+ 48732123296135508011609193786471617544941100388702269766318279457542306778657137612215255247835693051834863536094910966758454792861370950298719221859825896175787296631655662003448668435251210p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501900p -0.3
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870501910p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502400p 0.9
+ 97464246592271016023218387572943235089882200777404539532636558915084613557314275224430510495671386103669727072189821933516909585722741900597438443719651792351574593263311324006897336870502410p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004300p -0.3
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004310p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004800p 0.9
+ 194928493184542032046436775145886470179764401554809079065273117830169227114628550448861020991342772207339454144379643867033819171445483801194876887439303584703149186526622648013794673741004810p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009100p -0.3
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009110p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009600p 0.9
+ 389856986369084064092873550291772940359528803109618158130546235660338454229257100897722041982685544414678908288759287734067638342890967602389753774878607169406298373053245296027589347482009610p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018700p -0.3
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964018710p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019200p 0.9
+ 779713972738168128185747100583545880719057606219236316261092471320676908458514201795444083965371088829357816577518575468135276685781935204779507549757214338812596746106490592055178694964019210p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037900p -0.3
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928037910p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038400p 0.9
+ 1559427945476336256371494201167091761438115212438472632522184942641353816917028403590888167930742177658715633155037150936270553371563870409559015099514428677625193492212981184110357389928038410p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076300p -0.3
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076310p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076800p 0.9
+ 3118855890952672512742988402334183522876230424876945265044369885282707633834056807181776335861484355317431266310074301872541106743127740819118030199028857355250386984425962368220714779856076810p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153100p -0.3
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153110p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153600p 0.9
+ 6237711781905345025485976804668367045752460849753890530088739770565415267668113614363552671722968710634862532620148603745082213486255481638236060398057714710500773968851924736441429559712153610p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306700p -0.3
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424306710p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307200p 0.9
+ 12475423563810690050971953609336734091504921699507781060177479541130830535336227228727105343445937421269725065240297207490164426972510963276472120796115429421001547937703849472882859119424307210p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613900p -0.3
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848613910p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614400p 0.9
+ 24950847127621380101943907218673468183009843399015562120354959082261661070672454457454210686891874842539450130480594414980328853945021926552944241592230858842003095875407698945765718238848614410p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228300p -0.3
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228310p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228800p 0.9
+ 49901694255242760203887814437346936366019686798031124240709918164523322141344908914908421373783749685078900260961188829960657707890043853105888483184461717684006191750815397891531436477697228810p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457100p -0.3
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457110p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457600p 0.9
+ 99803388510485520407775628874693872732039373596062248481419836329046644282689817829816842747567499370157800521922377659921315415780087706211776966368923435368012383501630795783062872955394457610p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914700p -0.3
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788914710p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915200p 0.9
+ 199606777020971040815551257749387745464078747192124496962839672658093288565379635659633685495134998740315601043844755319842630831560175412423553932737846870736024767003261591566125745910788915210p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829900p -0.3
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577829910p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830400p 0.9
+ 399213554041942081631102515498775490928157494384248993925679345316186577130759271319267370990269997480631202087689510639685261663120350824847107865475693741472049534006523183132251491821577830410p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660300p -0.3
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660310p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660800p 0.9
+ 798427108083884163262205030997550981856314988768497987851358690632373154261518542638534741980539994961262404175379021279370523326240701649694215730951387482944099068013046366264502983643155660810p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321100p -0.3
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321110p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321600p 0.9
+ 1596854216167768326524410061995101963712629977536995975702717381264746308523037085277069483961079989922524808350758042558741046652481403299388431461902774965888198136026092732529005967286311321610p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642700p -0.3
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622642710p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643200p 0.9
+ 3193708432335536653048820123990203927425259955073991951405434762529492617046074170554138967922159979845049616701516085117482093304962806598776862923805549931776396272052185465058011934572622643210p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285900p -0.3
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245285910p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286400p 0.9
+ 6387416864671073306097640247980407854850519910147983902810869525058985234092148341108277935844319959690099233403032170234964186609925613197553725847611099863552792544104370930116023869145245286410p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572300p -0.3
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572310p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572800p 0.9
+ 12774833729342146612195280495960815709701039820295967805621739050117970468184296682216555871688639919380198466806064340469928373219851226395107451695222199727105585088208741860232047738290490572810p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145100p -0.3
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145110p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145600p 0.9
+ 25549667458684293224390560991921631419402079640591935611243478100235940936368593364433111743377279838760396933612128680939856746439702452790214903390444399454211170176417483720464095476580981145610p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290700p -0.3
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962290710p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291200p 0.9
+ 51099334917368586448781121983843262838804159281183871222486956200471881872737186728866223486754559677520793867224257361879713492879404905580429806780888798908422340352834967440928190953161962291210p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581900p -0.3
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924581910p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582400p 0.9
+ 102198669834737172897562243967686525677608318562367742444973912400943763745474373457732446973509119355041587734448514723759426985758809811160859613561777597816844680705669934881856381906323924582410p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164300p -0.3
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164310p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164800p 0.9
+ 204397339669474345795124487935373051355216637124735484889947824801887527490948746915464893947018238710083175468897029447518853971517619622321719227123555195633689361411339869763712763812647849164810p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329100p -0.3
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329110p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329600p 0.9
+ 408794679338948691590248975870746102710433274249470969779895649603775054981897493830929787894036477420166350937794058895037707943035239244643438454247110391267378722822679739527425527625295698329610p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658700p -0.3
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396658710p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659200p 0.9
+ 817589358677897383180497951741492205420866548498941939559791299207550109963794987661859575788072954840332701875588117790075415886070478489286876908494220782534757445645359479054851055250591396659210p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317900p -0.3
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793317910p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318400p 0.9
+ 1635178717355794766360995903482984410841733096997883879119582598415100219927589975323719151576145909680665403751176235580150831772140956978573753816988441565069514891290718958109702110501182793318410p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636300p -0.3
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636310p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636800p 0.9
+ 3270357434711589532721991806965968821683466193995767758239165196830200439855179950647438303152291819361330807502352471160301663544281913957147507633976883130139029782581437916219404221002365586636810p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273100p -0.3
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273110p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273600p 0.9
+ 6540714869423179065443983613931937643366932387991535516478330393660400879710359901294876606304583638722661615004704942320603327088563827914295015267953766260278059565162875832438808442004731173273610p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546700p -0.3
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346546710p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547200p 0.9
+ 13081429738846358130887967227863875286733864775983071032956660787320801759420719802589753212609167277445323230009409884641206654177127655828590030535907532520556119130325751664877616884009462346547210p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093900p -0.3
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693093910p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094400p 0.9
+ 26162859477692716261775934455727750573467729551966142065913321574641603518841439605179506425218334554890646460018819769282413308354255311657180061071815065041112238260651503329755233768018924693094410p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188300p -0.3
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188310p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188800p 0.9
+ 52325718955385432523551868911455501146935459103932284131826643149283207037682879210359012850436669109781292920037639538564826616708510623314360122143630130082224476521303006659510467536037849386188810p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377100p -0.3
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377110p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377600p 0.9
+ 104651437910770865047103737822911002293870918207864568263653286298566414075365758420718025700873338219562585840075279077129653233417021246628720244287260260164448953042606013319020935072075698772377610p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754700p -0.3
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544754710p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755200p 0.9
+ 209302875821541730094207475645822004587741836415729136527306572597132828150731516841436051401746676439125171680150558154259306466834042493257440488574520520328897906085212026638041870144151397544755210p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509900p -0.3
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089509910p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510400p 0.9
+ 418605751643083460188414951291644009175483672831458273054613145194265656301463033682872102803493352878250343360301116308518612933668084986514880977149041040657795812170424053276083740288302795089510410p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020300p -0.3
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020310p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020800p 0.9
+ 837211503286166920376829902583288018350967345662916546109226290388531312602926067365744205606986705756500686720602232617037225867336169973029761954298082081315591624340848106552167480576605590179020810p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041100p -0.3
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041110p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041600p 0.9
+ 1674423006572333840753659805166576036701934691325833092218452580777062625205852134731488411213973411513001373441204465234074451734672339946059523908596164162631183248681696213104334961153211180358041610p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082700p -0.3
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716082710p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083200p 0.9
+ 3348846013144667681507319610333152073403869382651666184436905161554125250411704269462976822427946823026002746882408930468148903469344679892119047817192328325262366497363392426208669922306422360716083210p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165900p -0.3
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432165910p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166400p 0.9
+ 6697692026289335363014639220666304146807738765303332368873810323108250500823408538925953644855893646052005493764817860936297806938689359784238095634384656650524732994726784852417339844612844721432166410p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332300p -0.3
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332310p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332800p 0.9
+ 13395384052578670726029278441332608293615477530606664737747620646216501001646817077851907289711787292104010987529635721872595613877378719568476191268769313301049465989453569704834679689225689442864332810p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665100p -0.3
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665110p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665600p 0.9
+ 26790768105157341452058556882665216587230955061213329475495241292433002003293634155703814579423574584208021975059271443745191227754757439136952382537538626602098931978907139409669359378451378885728665610p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330700p -0.3
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457330710p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331200p 0.9
+ 53581536210314682904117113765330433174461910122426658950990482584866004006587268311407629158847149168416043950118542887490382455509514878273904765075077253204197863957814278819338718756902757771457331210p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661900p -0.3
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914661910p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662400p 0.9
+ 107163072420629365808234227530660866348923820244853317901980965169732008013174536622815258317694298336832087900237085774980764911019029756547809530150154506408395727915628557638677437513805515542914662410p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324300p -0.3
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324310p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324800p 0.9
+ 214326144841258731616468455061321732697847640489706635803961930339464016026349073245630516635388596673664175800474171549961529822038059513095619060300309012816791455831257115277354875027611031085829324810p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649100p -0.3
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649110p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649600p 0.9
+ 428652289682517463232936910122643465395695280979413271607923860678928032052698146491261033270777193347328351600948343099923059644076119026191238120600618025633582911662514230554709750055222062171658649610p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298700p -0.3
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317298710p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299200p 0.9
+ 857304579365034926465873820245286930791390561958826543215847721357856064105396292982522066541554386694656703201896686199846119288152238052382476241201236051267165823325028461109419500110444124343317299210p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597900p -0.3
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634597910p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598400p 0.9
+ 1714609158730069852931747640490573861582781123917653086431695442715712128210792585965044133083108773389313406403793372399692238576304476104764952482402472102534331646650056922218839000220888248686634598410p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196300p -0.3
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196310p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196800p 0.9
+ 3429218317460139705863495280981147723165562247835306172863390885431424256421585171930088266166217546778626812807586744799384477152608952209529904964804944205068663293300113844437678000441776497373269196810p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393100p -0.3
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393110p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393600p 0.9
+ 6858436634920279411726990561962295446331124495670612345726781770862848512843170343860176532332435093557253625615173489598768954305217904419059809929609888410137326586600227688875356000883552994746538393610p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786700p -0.3
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076786710p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787200p 0.9
+ 13716873269840558823453981123924590892662248991341224691453563541725697025686340687720353064664870187114507251230346979197537908610435808838119619859219776820274653173200455377750712001767105989493076787210p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573900p -0.3
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153573910p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574400p 0.9
+ 27433746539681117646907962247849181785324497982682449382907127083451394051372681375440706129329740374229014502460693958395075817220871617676239239718439553640549306346400910755501424003534211978986153574410p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148300p -0.3
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148310p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148800p 0.9
+ 54867493079362235293815924495698363570648995965364898765814254166902788102745362750881412258659480748458029004921387916790151634441743235352478479436879107281098612692801821511002848007068423957972307148810p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297100p -0.3
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297110p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297600p 0.9
+ 109734986158724470587631848991396727141297991930729797531628508333805576205490725501762824517318961496916058009842775833580303268883486470704956958873758214562197225385603643022005696014136847915944614297610p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594700p -0.3
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228594710p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595200p 0.9
+ 219469972317448941175263697982793454282595983861459595063257016667611152410981451003525649034637922993832116019685551667160606537766972941409913917747516429124394450771207286044011392028273695831889228595210p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189900p -0.3
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457189910p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190400p 0.9
+ 438939944634897882350527395965586908565191967722919190126514033335222304821962902007051298069275845987664232039371103334321213075533945882819827835495032858248788901542414572088022784056547391663778457190410p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380300p -0.3
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380310p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380800p 0.9
+ 877879889269795764701054791931173817130383935445838380253028066670444609643925804014102596138551691975328464078742206668642426151067891765639655670990065716497577803084829144176045568113094783327556914380810p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761100p -0.3
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761110p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761600p 0.9
+ 1755759778539591529402109583862347634260767870891676760506056133340889219287851608028205192277103383950656928157484413337284852302135783531279311341980131432995155606169658288352091136226189566655113828761610p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522700p -0.3
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657522710p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523200p 0.9
+ 3511519557079183058804219167724695268521535741783353521012112266681778438575703216056410384554206767901313856314968826674569704604271567062558622683960262865990311212339316576704182272452379133310227657523210p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045900p -0.3
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315045910p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046400p 0.9
+ 7023039114158366117608438335449390537043071483566707042024224533363556877151406432112820769108413535802627712629937653349139409208543134125117245367920525731980622424678633153408364544904758266620455315046410p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092300p -0.3
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092310p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092800p 0.9
+ 14046078228316732235216876670898781074086142967133414084048449066727113754302812864225641538216827071605255425259875306698278818417086268250234490735841051463961244849357266306816729089809516533240910630092810p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185100p -0.3
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185110p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185600p 0.9
+ 28092156456633464470433753341797562148172285934266828168096898133454227508605625728451283076433654143210510850519750613396557636834172536500468981471682102927922489698714532613633458179619033066481821260185610p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370700p -0.3
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520370710p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371200p 0.9
+ 56184312913266928940867506683595124296344571868533656336193796266908455017211251456902566152867308286421021701039501226793115273668345073000937962943364205855844979397429065227266916359238066132963642520371210p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741900p -0.3
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040741910p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742400p 0.9
+ 112368625826533857881735013367190248592689143737067312672387592533816910034422502913805132305734616572842043402079002453586230547336690146001875925886728411711689958794858130454533832718476132265927285040742410p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484300p -0.3
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484310p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484800p 0.9
+ 224737251653067715763470026734380497185378287474134625344775185067633820068845005827610264611469233145684086804158004907172461094673380292003751851773456823423379917589716260909067665436952264531854570081484810p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969100p -0.3
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969110p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969600p 0.9
+ 449474503306135431526940053468760994370756574948269250689550370135267640137690011655220529222938466291368173608316009814344922189346760584007503703546913646846759835179432521818135330873904529063709140162969610p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938700p -0.3
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325938710p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939200p 0.9
+ 898949006612270863053880106937521988741513149896538501379100740270535280275380023310441058445876932582736347216632019628689844378693521168015007407093827293693519670358865043636270661747809058127418280325939210p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877900p -0.3
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651877910p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878400p 0.9
+ 1797898013224541726107760213875043977483026299793077002758201480541070560550760046620882116891753865165472694433264039257379688757387042336030014814187654587387039340717730087272541323495618116254836560651878410p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756300p -0.3
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756310p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756800p 0.9
+ 3595796026449083452215520427750087954966052599586154005516402961082141121101520093241764233783507730330945388866528078514759377514774084672060029628375309174774078681435460174545082646991236232509673121303756810p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513100p -0.3
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513110p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513600p 0.9
+ 7191592052898166904431040855500175909932105199172308011032805922164282242203040186483528467567015460661890777733056157029518755029548169344120059256750618349548157362870920349090165293982472465019346242607513610p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026700p -0.3
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215026710p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027200p 0.9
+ 14383184105796333808862081711000351819864210398344616022065611844328564484406080372967056935134030921323781555466112314059037510059096338688240118513501236699096314725741840698180330587964944930038692485215027210p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053900p -0.3
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430053910p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054400p 0.9
+ 28766368211592667617724163422000703639728420796689232044131223688657128968812160745934113870268061842647563110932224628118075020118192677376480237027002473398192629451483681396360661175929889860077384970430054410p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108300p -0.3
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108310p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108800p 0.9
+ 57532736423185335235448326844001407279456841593378464088262447377314257937624321491868227740536123685295126221864449256236150040236385354752960474054004946796385258902967362792721322351859779720154769940860108810p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217100p -0.3
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217110p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217600p 0.9
+ 115065472846370670470896653688002814558913683186756928176524894754628515875248642983736455481072247370590252443728898512472300080472770709505920948108009893592770517805934725585442644703719559440309539881720217610p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434700p -0.3
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440434710p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435200p 0.9
+ 230130945692741340941793307376005629117827366373513856353049789509257031750497285967472910962144494741180504887457797024944600160945541419011841896216019787185541035611869451170885289407439118880619079763440435210p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869900p -0.3
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880869910p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870400p 0.9
+ 460261891385482681883586614752011258235654732747027712706099579018514063500994571934945821924288989482361009774915594049889200321891082838023683792432039574371082071223738902341770578814878237761238159526880870410p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740300p -0.3
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740310p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740800p 0.9
+ 920523782770965363767173229504022516471309465494055425412199158037028127001989143869891643848577978964722019549831188099778400643782165676047367584864079148742164142447477804683541157629756475522476319053761740810p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481100p -0.3
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481110p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481600p 0.9
+ 1841047565541930727534346459008045032942618930988110850824398316074056254003978287739783287697155957929444039099662376199556801287564331352094735169728158297484328284894955609367082315259512951044952638107523481610p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962700p -0.3
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046962710p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963200p 0.9
+ 3682095131083861455068692918016090065885237861976221701648796632148112508007956575479566575394311915858888078199324752399113602575128662704189470339456316594968656569789911218734164630519025902089905276215046963210p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925900p -0.3
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093925910p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926400p 0.9
+ 7364190262167722910137385836032180131770475723952443403297593264296225016015913150959133150788623831717776156398649504798227205150257325408378940678912633189937313139579822437468329261038051804179810552430093926410p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852300p -0.3
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852310p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852800p 0.9
+ 14728380524335445820274771672064360263540951447904886806595186528592450032031826301918266301577247663435552312797299009596454410300514650816757881357825266379874626279159644874936658522076103608359621104860187852810p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705100p -0.3
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705110p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705600p 0.9
+ 29456761048670891640549543344128720527081902895809773613190373057184900064063652603836532603154495326871104625594598019192908820601029301633515762715650532759749252558319289749873317044152207216719242209720375705610p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410700p -0.3
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751410710p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411200p 0.9
+ 58913522097341783281099086688257441054163805791619547226380746114369800128127305207673065206308990653742209251189196038385817641202058603267031525431301065519498505116638579499746634088304414433438484419440751411210p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821900p -0.3
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502821910p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822400p 0.9
+ 117827044194683566562198173376514882108327611583239094452761492228739600256254610415346130412617981307484418502378392076771635282404117206534063050862602131038997010233277158999493268176608828866876968838881502822410p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644300p -0.3
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644310p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644800p 0.9
+ 235654088389367133124396346753029764216655223166478188905522984457479200512509220830692260825235962614968837004756784153543270564808234413068126101725204262077994020466554317998986536353217657733753937677763005644810p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289100p -0.3
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289110p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289600p 0.9
+ 471308176778734266248792693506059528433310446332956377811045968914958401025018441661384521650471925229937674009513568307086541129616468826136252203450408524155988040933108635997973072706435315467507875355526011289610p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578700p -0.3
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022578710p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579200p 0.9
+ 942616353557468532497585387012119056866620892665912755622091937829916802050036883322769043300943850459875348019027136614173082259232937652272504406900817048311976081866217271995946145412870630935015750711052022579210p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157900p -0.3
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045157910p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158400p 0.9
+ 1885232707114937064995170774024238113733241785331825511244183875659833604100073766645538086601887700919750696038054273228346164518465875304545008813801634096623952163732434543991892290825741261870031501422104045158410p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316300p -0.3
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316310p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316800p 0.9
+ 3770465414229874129990341548048476227466483570663651022488367751319667208200147533291076173203775401839501392076108546456692329036931750609090017627603268193247904327464869087983784581651482523740063002844208090316810p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633100p -0.3
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633110p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633600p 0.9
+ 7540930828459748259980683096096952454932967141327302044976735502639334416400295066582152346407550803679002784152217092913384658073863501218180035255206536386495808654929738175967569163302965047480126005688416180633610p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266700p -0.3
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361266710p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267200p 0.9
+ 15081861656919496519961366192193904909865934282654604089953471005278668832800590133164304692815101607358005568304434185826769316147727002436360070510413072772991617309859476351935138326605930094960252011376832361267210p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533900p -0.3
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722533910p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534400p 0.9
+ 30163723313838993039922732384387809819731868565309208179906942010557337665601180266328609385630203214716011136608868371653538632295454004872720141020826145545983234619718952703870276653211860189920504022753664722534410p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068300p -0.3
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068310p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068800p 0.9
+ 60327446627677986079845464768775619639463737130618416359813884021114675331202360532657218771260406429432022273217736743307077264590908009745440282041652291091966469239437905407740553306423720379841008045507329445068810p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137100p -0.3
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137110p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137600p 0.9
+ 120654893255355972159690929537551239278927474261236832719627768042229350662404721065314437542520812858864044546435473486614154529181816019490880564083304582183932938478875810815481106612847440759682016091014658890137610p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274700p -0.3
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780274710p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275200p 0.9
+ 241309786510711944319381859075102478557854948522473665439255536084458701324809442130628875085041625717728089092870946973228309058363632038981761128166609164367865876957751621630962213225694881519364032182029317780275210p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549900p -0.3
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560549910p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550400p 0.9
+ 482619573021423888638763718150204957115709897044947330878511072168917402649618884261257750170083251435456178185741893946456618116727264077963522256333218328735731753915503243261924426451389763038728064364058635560550410p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100300p -0.3
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100310p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100800p 0.9
+ 965239146042847777277527436300409914231419794089894661757022144337834805299237768522515500340166502870912356371483787892913236233454528155927044512666436657471463507831006486523848852902779526077456128728117271121100810p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201100p -0.3
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201110p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201600p 0.9
+ 1930478292085695554555054872600819828462839588179789323514044288675669610598475537045031000680333005741824712742967575785826472466909056311854089025332873314942927015662012973047697705805559052154912257456234542242201610p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402700p -0.3
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484402710p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403200p 0.9
+ 3860956584171391109110109745201639656925679176359578647028088577351339221196951074090062001360666011483649425485935151571652944933818112623708178050665746629885854031324025946095395411611118104309824514912469084484403210p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805900p -0.3
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968805910p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806400p 0.9
+ 7721913168342782218220219490403279313851358352719157294056177154702678442393902148180124002721332022967298850971870303143305889867636225247416356101331493259771708062648051892190790823222236208619649029824938168968806410p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612300p -0.3
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612310p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612800p 0.9
+ 15443826336685564436440438980806558627702716705438314588112354309405356884787804296360248005442664045934597701943740606286611779735272450494832712202662986519543416125296103784381581646444472417239298059649876337937612810p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225100p -0.3
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225110p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225600p 0.9
+ 30887652673371128872880877961613117255405433410876629176224708618810713769575608592720496010885328091869195403887481212573223559470544900989665424405325973039086832250592207568763163292888944834478596119299752675875225610p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450700p -0.3
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750450710p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451200p 0.9
+ 61775305346742257745761755923226234510810866821753258352449417237621427539151217185440992021770656183738390807774962425146447118941089801979330848810651946078173664501184415137526326585777889668957192238599505351750451210p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901900p -0.3
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500901910p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902400p 0.9
+ 123550610693484515491523511846452469021621733643506516704898834475242855078302434370881984043541312367476781615549924850292894237882179603958661697621303892156347329002368830275052653171555779337914384477199010703500902410p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804300p -0.3
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804310p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804800p 0.9
+ 247101221386969030983047023692904938043243467287013033409797668950485710156604868741763968087082624734953563231099849700585788475764359207917323395242607784312694658004737660550105306343111558675828768954398021407001804810p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609100p -0.3
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609110p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609600p 0.9
+ 494202442773938061966094047385809876086486934574026066819595337900971420313209737483527936174165249469907126462199699401171576951528718415834646790485215568625389316009475321100210612686223117351657537908796042814003609610p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218700p -0.3
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007218710p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219200p 0.9
+ 988404885547876123932188094771619752172973869148052133639190675801942840626419474967055872348330498939814252924399398802343153903057436831669293580970431137250778632018950642200421225372446234703315075817592085628007219210p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437900p -0.3
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014437910p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438400p 0.9
+ 1976809771095752247864376189543239504345947738296104267278381351603885681252838949934111744696660997879628505848798797604686307806114873663338587161940862274501557264037901284400842450744892469406630151635184171256014438410p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876300p -0.3
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876310p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876800p 0.9
+ 3953619542191504495728752379086479008691895476592208534556762703207771362505677899868223489393321995759257011697597595209372615612229747326677174323881724549003114528075802568801684901489784938813260303270368342512028876810p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753100p -0.3
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753110p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753600p 0.9
+ 7907239084383008991457504758172958017383790953184417069113525406415542725011355799736446978786643991518514023395195190418745231224459494653354348647763449098006229056151605137603369802979569877626520606540736685024057753610p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506700p -0.3
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115506710p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507200p 0.9
+ 15814478168766017982915009516345916034767581906368834138227050812831085450022711599472893957573287983037028046790390380837490462448918989306708697295526898196012458112303210275206739605959139755253041213081473370048115507210p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013900p -0.3
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231013910p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014400p 0.9
+ 31628956337532035965830019032691832069535163812737668276454101625662170900045423198945787915146575966074056093580780761674980924897837978613417394591053796392024916224606420550413479211918279510506082426162946740096231014410p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028300p -0.3
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028310p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028800p 0.9
+ 63257912675064071931660038065383664139070327625475336552908203251324341800090846397891575830293151932148112187161561523349961849795675957226834789182107592784049832449212841100826958423836559021012164852325893480192462028810p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057100p -0.3
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057110p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057600p 0.9
+ 126515825350128143863320076130767328278140655250950673105816406502648683600181692795783151660586303864296224374323123046699923699591351914453669578364215185568099664898425682201653916847673118042024329704651786960384924057610p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114700p -0.3
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848114710p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115200p 0.9
+ 253031650700256287726640152261534656556281310501901346211632813005297367200363385591566303321172607728592448748646246093399847399182703828907339156728430371136199329796851364403307833695346236084048659409303573920769848115210p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229900p -0.3
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696229910p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230400p 0.9
+ 506063301400512575453280304523069313112562621003802692423265626010594734400726771183132606642345215457184897497292492186799694798365407657814678313456860742272398659593702728806615667390692472168097318818607147841539696230410p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460300p -0.3
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460310p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460800p 0.9
+ 1012126602801025150906560609046138626225125242007605384846531252021189468801453542366265213284690430914369794994584984373599389596730815315629356626913721484544797319187405457613231334781384944336194637637214295683079392460810p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921100p -0.3
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921110p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921600p 0.9
+ 2024253205602050301813121218092277252450250484015210769693062504042378937602907084732530426569380861828739589989169968747198779193461630631258713253827442969089594638374810915226462669562769888672389275274428591366158784921610p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842700p -0.3
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569842710p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843200p 0.9
+ 4048506411204100603626242436184554504900500968030421539386125008084757875205814169465060853138761723657479179978339937494397558386923261262517426507654885938179189276749621830452925339125539777344778550548857182732317569843210p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685900p -0.3
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139685910p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686400p 0.9
+ 8097012822408201207252484872369109009801001936060843078772250016169515750411628338930121706277523447314958359956679874988795116773846522525034853015309771876358378553499243660905850678251079554689557101097714365464635139686410p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372300p -0.3
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372310p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372800p 0.9
+ 16194025644816402414504969744738218019602003872121686157544500032339031500823256677860243412555046894629916719913359749977590233547693045050069706030619543752716757106998487321811701356502159109379114202195428730929270279372810p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745100p -0.3
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745110p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745600p 0.9
+ 32388051289632804829009939489476436039204007744243372315089000064678063001646513355720486825110093789259833439826719499955180467095386090100139412061239087505433514213996974643623402713004318218758228404390857461858540558745610p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490700p -0.3
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117490710p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491200p 0.9
+ 64776102579265609658019878978952872078408015488486744630178000129356126003293026711440973650220187578519666879653438999910360934190772180200278824122478175010867028427993949287246805426008636437516456808781714923717081117491210p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981900p -0.3
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234981910p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982400p 0.9
+ 129552205158531219316039757957905744156816030976973489260356000258712252006586053422881947300440375157039333759306877999820721868381544360400557648244956350021734056855987898574493610852017272875032913617563429847434162234982410p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964300p -0.3
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964310p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964800p 0.9
+ 259104410317062438632079515915811488313632061953946978520712000517424504013172106845763894600880750314078667518613755999641443736763088720801115296489912700043468113711975797148987221704034545750065827235126859694868324469964810p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929100p -0.3
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929110p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929600p 0.9
+ 518208820634124877264159031831622976627264123907893957041424001034849008026344213691527789201761500628157335037227511999282887473526177441602230592979825400086936227423951594297974443408069091500131654470253719389736648939929610p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858700p -0.3
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879858710p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859200p 0.9
+ 1036417641268249754528318063663245953254528247815787914082848002069698016052688427383055578403523001256314670074455023998565774947052354883204461185959650800173872454847903188595948886816138183000263308940507438779473297879859210p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717900p -0.3
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759717910p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718400p 0.9
+ 2072835282536499509056636127326491906509056495631575828165696004139396032105376854766111156807046002512629340148910047997131549894104709766408922371919301600347744909695806377191897773632276366000526617881014877558946595759718410p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436300p -0.3
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436310p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436800p 0.9
+ 4145670565072999018113272254652983813018112991263151656331392008278792064210753709532222313614092005025258680297820095994263099788209419532817844743838603200695489819391612754383795547264552732001053235762029755117893191519436810p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873100p -0.3
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873110p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873600p 0.9
+ 8291341130145998036226544509305967626036225982526303312662784016557584128421507419064444627228184010050517360595640191988526199576418839065635689487677206401390979638783225508767591094529105464002106471524059510235786383038873610p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746700p -0.3
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077746710p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747200p 0.9
+ 16582682260291996072453089018611935252072451965052606625325568033115168256843014838128889254456368020101034721191280383977052399152837678131271378975354412802781959277566451017535182189058210928004212943048119020471572766077747210p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493900p -0.3
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155493910p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494400p 0.9
+ 33165364520583992144906178037223870504144903930105213250651136066230336513686029676257778508912736040202069442382560767954104798305675356262542757950708825605563918555132902035070364378116421856008425886096238040943145532155494410p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988300p -0.3
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988310p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988800p 0.9
+ 66330729041167984289812356074447741008289807860210426501302272132460673027372059352515557017825472080404138884765121535908209596611350712525085515901417651211127837110265804070140728756232843712016851772192476081886291064310988810p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977100p -0.3
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977110p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977600p 0.9
+ 132661458082335968579624712148895482016579615720420853002604544264921346054744118705031114035650944160808277769530243071816419193222701425050171031802835302422255674220531608140281457512465687424033703544384952163772582128621977610p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954700p -0.3
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243954710p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955200p 0.9
+ 265322916164671937159249424297790964033159231440841706005209088529842692109488237410062228071301888321616555539060486143632838386445402850100342063605670604844511348441063216280562915024931374848067407088769904327545164257243955210p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909900p -0.3
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487909910p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910400p 0.9
+ 530645832329343874318498848595581928066318462881683412010418177059685384218976474820124456142603776643233111078120972287265676772890805700200684127211341209689022696882126432561125830049862749696134814177539808655090328514487910410p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820300p -0.3
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820310p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820800p 0.9
+ 1061291664658687748636997697191163856132636925763366824020836354119370768437952949640248912285207553286466222156241944574531353545781611400401368254422682419378045393764252865122251660099725499392269628355079617310180657028975820810p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641100p -0.3
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641110p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641600p 0.9
+ 2122583329317375497273995394382327712265273851526733648041672708238741536875905899280497824570415106572932444312483889149062707091563222800802736508845364838756090787528505730244503320199450998784539256710159234620361314057951641610p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282700p -0.3
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903282710p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283200p 0.9
+ 4245166658634750994547990788764655424530547703053467296083345416477483073751811798560995649140830213145864888624967778298125414183126445601605473017690729677512181575057011460489006640398901997569078513420318469240722628115903283210p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565900p -0.3
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806565910p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566400p 0.9
+ 8490333317269501989095981577529310849061095406106934592166690832954966147503623597121991298281660426291729777249935556596250828366252891203210946035381459355024363150114022920978013280797803995138157026840636938481445256231806566410p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132300p -0.3
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132310p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132800p 0.9
+ 16980666634539003978191963155058621698122190812213869184333381665909932295007247194243982596563320852583459554499871113192501656732505782406421892070762918710048726300228045841956026561595607990276314053681273876962890512463613132810p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265100p -0.3
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265110p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265600p 0.9
+ 33961333269078007956383926310117243396244381624427738368666763331819864590014494388487965193126641705166919108999742226385003313465011564812843784141525837420097452600456091683912053123191215980552628107362547753925781024927226265610p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530700p -0.3
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452530710p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531200p 0.9
+ 67922666538156015912767852620234486792488763248855476737333526663639729180028988776975930386253283410333838217999484452770006626930023129625687568283051674840194905200912183367824106246382431961105256214725095507851562049854452531210p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061900p -0.3
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905061910p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062400p 0.9
+ 135845333076312031825535705240468973584977526497710953474667053327279458360057977553951860772506566820667676435998968905540013253860046259251375136566103349680389810401824366735648212492764863922210512429450191015703124099708905062410p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124300p -0.3
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124310p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124800p 0.9
+ 271690666152624063651071410480937947169955052995421906949334106654558916720115955107903721545013133641335352871997937811080026507720092518502750273132206699360779620803648733471296424985529727844421024858900382031406248199417810124810p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249100p -0.3
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249110p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249600p 0.9
+ 543381332305248127302142820961875894339910105990843813898668213309117833440231910215807443090026267282670705743995875622160053015440185037005500546264413398721559241607297466942592849971059455688842049717800764062812496398835620249610p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498700p -0.3
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240498710p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499200p 0.9
+ 1086762664610496254604285641923751788679820211981687627797336426618235666880463820431614886180052534565341411487991751244320106030880370074011001092528826797443118483214594933885185699942118911377684099435601528125624992797671240499210p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997900p -0.3
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480997910p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998400p 0.9
+ 2173525329220992509208571283847503577359640423963375255594672853236471333760927640863229772360105069130682822975983502488640212061760740148022002185057653594886236966429189867770371399884237822755368198871203056251249985595342480998410p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996300p -0.3
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996310p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996800p 0.9
+ 4347050658441985018417142567695007154719280847926750511189345706472942667521855281726459544720210138261365645951967004977280424123521480296044004370115307189772473932858379735540742799768475645510736397742406112502499971190684961996810p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993100p -0.3
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993110p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993600p 0.9
+ 8694101316883970036834285135390014309438561695853501022378691412945885335043710563452919089440420276522731291903934009954560848247042960592088008740230614379544947865716759471081485599536951291021472795484812225004999942381369923993610p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986700p -0.3
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847986710p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987200p 0.9
+ 17388202633767940073668570270780028618877123391707002044757382825891770670087421126905838178880840553045462583807868019909121696494085921184176017480461228759089895731433518942162971199073902582042945590969624450009999884762739847987210p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973900p -0.3
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695973910p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974400p 0.9
+ 34776405267535880147337140541560057237754246783414004089514765651783541340174842253811676357761681106090925167615736039818243392988171842368352034960922457518179791462867037884325942398147805164085891181939248900019999769525479695974410p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948300p -0.3
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948310p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948800p 0.9
+ 69552810535071760294674281083120114475508493566828008179029531303567082680349684507623352715523362212181850335231472079636486785976343684736704069921844915036359582925734075768651884796295610328171782363878497800039999539050959391948810p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897100p -0.3
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897110p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897600p 0.9
+ 139105621070143520589348562166240228951016987133656016358059062607134165360699369015246705431046724424363700670462944159272973571952687369473408139843689830072719165851468151537303769592591220656343564727756995600079999078101918783897610p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794700p -0.3
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567794710p 0.9
+ 278211242140287041178697124332480457902033974267312032716118125214268330721398738030493410862093448848727401340925888318545947143905374738946816279687379660145438331702936303074607539185182441312687129455513991200159998156203837567795200p 0.9
